# Keil uVision project coremark_pro.uvprojx, settings and files
target coremark_pro (6160000::V6.16::ARMCLANG)
  device: AP330MPA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.4
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: coremark_pro
  AfterMake: fromelf --bin --output bin\coremark_pro.bin bin\coremark_pro.axf
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: apollo330mP_evb ENABLE_CPU_HP_250 AM_UTIL_FAULTISR_PRINT AM_PACKAGE_BGA USE_PRESET=1 EZXML_NOMMAP=1 THDEBUG=0 AM_FREERTOS REPORT_THMALLOC_STATS=0 RUN_PSRAM_TIMING_SCAN SELECT_PRESET_ID=1 MITH_MEMORY_ONLY_VERSION=1 USE_CRC_TABLE=1 DEBUG_ACCURATE_BITS=0 PSRAM_APS25616N BMDEBUG=0 ENABLE_PMU HEAP_IN_PSRAM RUN_IN_SINGLE_TASK=1 AM_PART_APOLLO330P keil6
  c include: ../src/FreeRTOS_Plus_POSIX/include/private;../../../../../..;../src/benchmarks/consumer_v2/cjpeg;../src/benchmarks/darkmark/parser;../src;../src/benchmarks/darkmark/zip/zlib-1.2.8;../src/FreeRTOS_Plus_POSIX/include;../src/benchmarks/consumer_v2/cjpeg/data;../../../../../../devices;../src/mith/al/include;../../../../../../third_party/FreeRTOSv10.5.1/Source/include;../../../../../../CMSIS/AmbiqMicro/Include;../../../../bsp;../src/benchmarks/darkmark/sha;../../../../../../CMSIS/ARM/Include;../src/FreeRTOS_Plus_POSIX/FreeRTOS-Plus-POSIX/include;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo5;../src/benchmarks/fp/linpack;../../../../../../mcu/apollo330P;../src/benchmarks/fp/nnet;../../../../../../utils;../src/benchmarks/fp/fft_radix2;../src/benchmarks/core;../src/mith/include;../src/benchmarks/fp/loops;../src/FreeRTOS_Plus_POSIX/include/FreeRTOS_POSIX
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo330P/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group nnet_test
    ../src/workloads/nnet_test/: nnet_test.c
  group src
    ../src/mith/src/: md5.c mith_lib.c mith_workload.c th_bignum.c th_encode.c th_getopt.c th_lib.c th_math.c th_rand.c
  group radix2-big-64k
    ../src/workloads/radix2-big-64k/: radix2-big-64k.c
  group FreeRTOSv10.5.1_AMapollo5
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo5/: port.c portasm.c port_stimer.c port_systick_stimer.c
  group core
    ../src/workloads/core/: core.c
  group src
    ../src/mith/al/src/: al_file.c al_single.c al_smp.c th_al.c
  group src
    ../src/: am_resources.c am_time.c coremark_pro.c heap_4_external.c heap_5_external.c mpu_config.c mspi_psram_init.c rtos.c
  group parser-125k
    ../src/workloads/parser-125k/: parser-125k.c
  group linear_alg-mid-100x100-sp
    ../src/workloads/linear_alg-mid-100x100-sp/: linear_alg-mid-100x100-sp.c
  group zip-test
    ../src/workloads/zip-test/: zip-test.c
  group sha-test
    ../src/workloads/sha-test/: sha-test.c
  group source
    ../src/FreeRTOS_Plus_POSIX/FreeRTOS-Plus-POSIX/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group loops-all-mid-10k-sp
    ../src/workloads/loops-all-mid-10k-sp/: loops-all-mid-10k-sp.c
  group cjpeg-rose7-preset
    ../src/workloads/cjpeg-rose7-preset/: cjpeg-rose7-preset.c
  group cjpeg
    ../src/benchmarks/consumer_v2/cjpeg/: bmark_lite.c bm_lib.c cdjpeg.c cjpeg.c filedata.c jcapimin.c jcapistd.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jdatadst.c jerror.c jfdctint.c jmemansi.c jmemmgr.c jutils.c rdbmp.c
  group parser
    ../src/benchmarks/darkmark/parser/: ezxml.c parser.c
  group zlib-1.2.8
    ../src/benchmarks/darkmark/zip/zlib-1.2.8/: adler32.c compress.c crc32.c deflate.c gzclose.c gzlib.c infback.c inffast.c inflate.c inftrees.c trees.c uncompr.c zutil.c
  group data
    ../src/benchmarks/consumer_v2/cjpeg/data/: goose_bmp.c Rose256_bmp.c
  group ref-sp
    ../src/benchmarks/fp/nnet/ref-sp/: 1letter.c letters.c
  group sha
    ../src/benchmarks/darkmark/sha/: sha256.c shabench.c
  group ref
    ../src/benchmarks/fp/linpack/ref/: inputs_f32.c
  group linpack
    ../src/benchmarks/fp/linpack/: linpack.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group nnet
    ../src/benchmarks/fp/nnet/: nnet.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_pmu.c am_util_stdio.c
  group fft_radix2
    ../src/benchmarks/fp/fft_radix2/: fft_radix2.c
  group core
    ../src/benchmarks/core/: core_list_join.c core_matrix.c core_mith.c core_portme.c core_state.c core_util.c
  group ref-sp
    ../src/benchmarks/fp/loops/ref-sp/: 100.c 100k.c 100kdot.c 10k.c 10kdot.c 1k.c 1kdot.c 32.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group loops
    ../src/benchmarks/fp/loops/: loops.c
  group zip
    ../src/benchmarks/darkmark/zip/: zip_darkmark.c
  group ref-sp
    ../src/benchmarks/fp/fft_radix2/ref-sp/: 2K.c 32K.c 4K.c data3_big.c data4_mid.c data5_small.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../CMSIS/ARM/Lib/ARM/DSP_LIB_CM55/: arm_cortexM55f_math.lib
    ../../../../../../mcu/apollo330P/hal/mcu/keil6/bin/: libam_hal.lib
software components: Device:Startup 1.1.0
