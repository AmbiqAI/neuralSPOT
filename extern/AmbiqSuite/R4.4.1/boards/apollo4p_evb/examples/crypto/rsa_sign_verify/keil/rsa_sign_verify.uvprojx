# Keil uVision project rsa_sign_verify.uvprojx, settings and files
target rsa_sign_verify (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: rsa_sign_verify
  AfterMake: fromelf --bin --output bin\rsa_sign_verify.bin bin\rsa_sign_verify.axf
  AfterMake: fromelf -cedrst --output bin\rsa_sign_verify.txt bin\rsa_sign_verify.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO4P AM_PACKAGE_BGA AM_UTIL_FAULTISR_PRINT CC_IOT keil
  c include: ../../../../../..;../../../../../../devices;../../../../../../third_party/crypto/shared/include/pal/no_os;../../../../../../third_party/crypto/mbedtls/include;../../../../bsp;../src;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/crypto/shared/include/pal;../../../../../../mcu/apollo4p;../../../../../../third_party/crypto/host/include;../../../../../../utils;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib
  group src
    ../src/: am_resources.c rsa_sign_verify.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../third_party/crypto/host/lib/: libcc_312.lib libpal_no_os.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../../../third_party/crypto/mbedtls/library/: cryptombedtls.lib
