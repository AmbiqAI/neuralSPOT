# IAR project coremark_pro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_UTIL_FAULTISR_PRINT; SELECT_PRESET_ID=1; AM_PACKAGE_BGA; MITH_MEMORY_ONLY_VERSION=1; BMDEBUG=0; RUN_IN_SINGLE_TASK=1; AM_FREERTOS; USE_PRESET=1; THDEBUG=0; HEAP_IN_SSRAM_AND_PSRAM; DEBUG_ACCURATE_BITS=0; AM_PART_APOLLO4B; EZXML_NOMMAP=1; REPORT_THMALLOC_STATS=0; USE_CRC_TABLE=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src\FreeRTOS_Plus_POSIX\include\private; ..\src\benchmarks\fp\loops; ..\..\..\..\..\..\utils; ..\src\benchmarks\libjpeg; ..\src\benchmarks\darkmark\zip\zlib-1.2.8; ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\src\FreeRTOS_Plus_POSIX\include; ..\..\..\..\..\..\mcu\apollo4b; ..\src\benchmarks\darkmark\sha; ..\..\..\..\..\..; ..\..\..\..\..\..\devices; ..\src\FreeRTOS_Plus_POSIX\include\FreeRTOS_POSIX; ..\src\mith\include; ..\src\benchmarks\libbmp; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\portable\IAR\AMapollo4; ..\src\benchmarks\core; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\src\benchmarks\fp\linpack; ..\src; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\include; ..\src\benchmarks\fp\nnet; ..\src\benchmarks\darkmark\parser; ..\src\FreeRTOS_Plus_POSIX\FreeRTOS-Plus-POSIX\include; ..\src\benchmarks\fp\fft_radix2; ..\src\benchmarks\consumer_v2\cjpeg\data; ..\src\mith\al\include; ..\src\benchmarks\consumer_v2\cjpeg
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: coremark_pro.bin
  ILINK.IlinkOutputFile: coremark_pro.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\CMSIS\ARM\Lib\ARM\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_UTIL_FAULTISR_PRINT; SELECT_PRESET_ID=1; AM_PACKAGE_BGA; MITH_MEMORY_ONLY_VERSION=1; BMDEBUG=0; RUN_IN_SINGLE_TASK=1; AM_FREERTOS; USE_PRESET=1; THDEBUG=0; HEAP_IN_SSRAM_AND_PSRAM; DEBUG_ACCURATE_BITS=0; AM_PART_APOLLO4B; EZXML_NOMMAP=1; REPORT_THMALLOC_STATS=0; USE_CRC_TABLE=1
  group (top)
    ../src/workloads/cjpeg-rose7-preset/: cjpeg-rose7-preset.c
    ../src/: am_resources.c coremark_pro.c heap_4_external.c heap_5_external.c psram.c rtos.c
    ../src/workloads/radix2-big-64k/: radix2-big-64k.c
    ../src/workloads/loops-all-mid-10k-sp/: loops-all-mid-10k-sp.c
    ../src/workloads/nnet_test/: nnet_test.c
    ../src/workloads/sha-test/: sha-test.c
    ../src/workloads/linear_alg-mid-100x100-sp/: linear_alg-mid-100x100-sp.c
    ../src/workloads/zip-test/: zip-test.c
    ../src/mith/src/: md5.c mith_lib.c mith_workload.c th_bignum.c th_encode.c th_getopt.c th_lib.c th_math.c th_rand.c
    ../src/FreeRTOS_Plus_POSIX/FreeRTOS-Plus-POSIX/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
    ../src/workloads/core/: core.c
    ../src/workloads/parser-125k/: parser-125k.c
    ../src/mith/al/src/: al_file.c al_single.c al_smp.c th_al.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../src/benchmarks/darkmark/zip/: zip_darkmark.c
    ../src/benchmarks/fp/nnet/ref-sp/: 1letter.c letters.c
    ../src/benchmarks/fp/loops/: loops.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
    ../src/benchmarks/fp/fft_radix2/ref-sp/: 2K.c 32K.c 4K.c data3_big.c data4_mid.c data5_small.c
    ../src/benchmarks/darkmark/zip/zlib-1.2.8/: adler32.c compress.c crc32.c deflate.c gzclose.c gzlib.c infback.c inffast.c inflate.c inftrees.c trees.c uncompr.c zutil.c
    ../src/benchmarks/darkmark/sha/: sha256.c shabench.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../src/benchmarks/core/: core_list_join.c core_matrix.c core_mith.c core_portme.c core_state.c core_util.c
    ../src/benchmarks/fp/linpack/: linpack.c
    ../src/benchmarks/fp/linpack/ref/: inputs_f32.c
    ../src/benchmarks/consumer_v2/cjpeg/: bmark_lite.c bm_lib.c cdjpeg.c cjpeg.c filedata.c jcapimin.c jcapistd.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jdatadst.c jerror.c jfdctint.c jmemansi.c jmemmgr.c jutils.c rdbmp.c
    ../src/benchmarks/darkmark/parser/: ezxml.c parser.c
    ../src/benchmarks/fp/fft_radix2/: fft_radix2.c
    ../src/benchmarks/consumer_v2/cjpeg/data/: goose_bmp.c Rose256_bmp.c
    ../src/benchmarks/fp/loops/ref-sp/: 100.c 100k.c 100kdot.c 10k.c 10kdot.c 1k.c 1kdot.c 32.c
    ../src/benchmarks/fp/nnet/: nnet.c
    ./: startup_iar.c
