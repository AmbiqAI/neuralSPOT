# Keil uVision project while.uvprojx, settings and files
target while (ARM-ADS)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: while
  AfterMake: fromelf --bin --output bin\while.bin bin\while.axf
  AfterMake: fromelf -cedrst --output bin\while.txt bin\while.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PRINTF_BUFSIZE=256 AM_PACKAGE_BGA AM_PART_APOLLO3P keil
  c include: ../../../../../CMSIS/ARM/Include;../src;../../../../../mcu/apollo3p;../../../bsp;../../../../../CMSIS/AmbiqMicro/Include;../../../../..;../../../../../utils;../../../../../devices
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: while.c
  group utils
    ../../../../../utils/: am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3p/hal/keil/bin/: libam_hal.lib
