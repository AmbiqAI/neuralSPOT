# Keil uVision project coremark.uvprojx, settings and files
target coremark (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: coremark
  AfterMake: fromelf --bin --output bin\coremark.bin bin\coremark.axf
  AfterMake: fromelf -cedrst --output bin\coremark.txt bin\coremark.axf
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PRINTF_BUFSIZE=256 AM_PART_APOLLO4B COREMARK keil6
  c include: ../../../../../../utils;../../../../../..;../../../../../../CMSIS/ARM/Include;../src;../../../../bsp;../../../../../../mcu/apollo4b;../../../../../../devices;../../../../../../CMSIS/AmbiqMicro/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c am_time.c coremark.c core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group devices
    ../../../../../../devices/: am_devices_led.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
