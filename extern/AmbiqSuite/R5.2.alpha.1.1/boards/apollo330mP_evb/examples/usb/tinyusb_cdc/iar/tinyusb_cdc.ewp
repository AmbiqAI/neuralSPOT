# IAR project tinyusb_cdc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP330MPA-CBR AmbiqMicro AP330MPA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_CDC_USE_APP_BUF; AM_CFG_USB_DMA_MODE_1; AM_PACKAGE_BGA; CFG_TUSB_MCU=OPT_MCU_APOLLO5; AM_CFG_USB_EP3_IN_DBUF_ENABLE; AM_CFG_USB_EP2_OUT_DBUF_ENABLE; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_HIGH_SPEED; AM_PART_APOLLO330P; CFG_TUSB_DEBUG=0; apollo330mP_evb
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo330P; ..\..\..\..\..\..\third_party\tinyusb\source\src; ..\..\..\..\..\..\mcu\apollo330P\hal; ..\..\..\..\..\..\third_party\tinyusb\source\src\osal; ..\..\..\..\..\..\third_party\tinyusb\source\src\class\cdc; ..\..\..\..\..\..\third_party\tinyusb\source\src\common; ..\..\..\..\bsp; ..\..\..\..\..\..\devices; ..\..\..\..\..\..; ..\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc.bin
  ILINK.IlinkOutputFile: tinyusb_cdc.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo330P\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_CDC_USE_APP_BUF; AM_CFG_USB_DMA_MODE_1; AM_PACKAGE_BGA; CFG_TUSB_MCU=OPT_MCU_APOLLO5; AM_CFG_USB_EP3_IN_DBUF_ENABLE; AM_CFG_USB_EP2_OUT_DBUF_ENABLE; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_HIGH_SPEED; AM_PART_APOLLO330P; CFG_TUSB_DEBUG=0; apollo330mP_evb
  group (top)
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
    ../../../../../../third_party/tinyusb/ambiq_port/apollo5/: dcd_apollo5.c
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
    ../src/: am_resources.c apollo5_board.c tinyusb_cdc.c usb_descriptors.c
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ./: startup_iar.c
