# IAR project nemagfx_vg_ttf.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; VMEM_SIZE=0x180000; RUN_IN_HP_MODE; AM_FREERTOS; NEMA_PLATFORM=apollo4p_nemagfx; AM_PART_APOLLO4P; VMEM_BASEADDR=0x10060400; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; apollo4p_evb_disp_shield_rev2; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\portable\IAR\AMapollo4; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaVG; ..\src; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\..\..; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\include; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4p_nemagfx; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_vg_ttf.bin
  ILINK.IlinkOutputFile: nemagfx_vg_ttf.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4p_nemagfx\iar\bin\lib_nema_apollo4p_nemagfx.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; VMEM_SIZE=0x180000; RUN_IN_HP_MODE; AM_FREERTOS; NEMA_PLATFORM=apollo4p_nemagfx; AM_PART_APOLLO4P; VMEM_BASEADDR=0x10060400; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; apollo4p_evb_disp_shield_rev2; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT
  group (top)
    ../src/: am_resources.c display_task.c graphics_power_control.c gui_task.c nemagfx_vg_ttf.c psram.c render_task.c rtos.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../src/font/: DejaVuSans_ttf_kern.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../../devices/: am_devices_dc_dsi_raydium.c am_devices_dc_xspi_raydium.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
    ./: startup_iar.c
