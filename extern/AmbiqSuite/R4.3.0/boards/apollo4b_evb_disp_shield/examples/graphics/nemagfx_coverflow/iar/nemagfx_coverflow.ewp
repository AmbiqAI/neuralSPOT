# IAR project nemagfx_coverflow.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; PLATFORM=apollo4b_nemagfx; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; AM_FREERTOS; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; AM_PART_APOLLO4B; BAREMETAL; USE_TSI_MALLOC; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo4; ..\..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx; ..\src\generated; ..\src; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo4b\hal
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_coverflow.bin
  ILINK.IlinkOutputFile: nemagfx_coverflow.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx\iar\bin\lib_nema_apollo4b_nemagfx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; PLATFORM=apollo4b_nemagfx; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; AM_FREERTOS; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; AM_PART_APOLLO4B; BAREMETAL; USE_TSI_MALLOC; AM_PACKAGE_BGA
  group (top)
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../src/generated/: coverflow.c
    ../src/: am_resources.c gui_task.c nemagfx_coverflow.c rtos.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_nemadc_rm67162.c
    ./: startup_iar.c
