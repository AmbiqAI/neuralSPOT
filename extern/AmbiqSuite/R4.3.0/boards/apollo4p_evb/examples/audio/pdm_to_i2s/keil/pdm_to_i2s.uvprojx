# Keil uVision project pdm_to_i2s.uvprojx, settings and files
target pdm_to_i2s (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: pdm_to_i2s
  AfterMake: fromelf --bin --output bin\pdm_to_i2s.bin bin\pdm_to_i2s.axf
  AfterMake: fromelf -cedrst --output bin\pdm_to_i2s.txt bin\pdm_to_i2s.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: UNITY_INCLUDE_CONFIG_H AM_PART_APOLLO4P __FPU_PRESENT AM_UTIL_FAULTISR_PRINT AM_PACKAGE_BGA keil
  c include: ../src;../../../../../../mcu/apollo4p;../../../../../../utils;../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../CMSIS/ARM/Include;../../../../../../devices;../../../../bsp
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c pdm_to_i2s.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group SEGGER_RTT
    ../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../CMSIS/ARM/Lib/ARM/: arm_cortexM4lf_math.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
