# Keil uVision project watchdog.uvprojx, settings and files
target watchdog (ARM-ADS)
  device: AMAP42KL-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.0
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: watchdog
  AfterMake: fromelf --bin --output bin\watchdog.bin bin\watchdog.axf
  AfterMake: fromelf -cedrst --output bin\watchdog.txt bin\watchdog.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO4L AM_PACKAGE_BGA keil
  c misc: --reduce_paths
  c include: ../../../../../../mcu/apollo4l;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../utils;../../../../../..;../src;../../../../../../devices;../../../../../../CMSIS/ARM/Include;../../../../bsp
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4l/hal/mcu/keil/bin/libam_hal.lib
  group src
    ../src/: am_resources.c watchdog.c
  group devices
    ../../../../../../devices/: am_devices_led.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4l/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
