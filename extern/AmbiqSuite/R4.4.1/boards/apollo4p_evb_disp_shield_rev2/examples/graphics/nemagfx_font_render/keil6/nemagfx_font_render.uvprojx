# Keil uVision project nemagfx_font_render.uvprojx, settings and files
target nemagfx_font_render (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_font_render
  AfterMake: fromelf --bin --output bin\nemagfx_font_render.bin bin\nemagfx_font_render.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_font_render.txt bin\nemagfx_font_render.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK BAREMETAL AM_PACKAGE_BGA NEMA_PLATFORM=apollo4p_nemagfx LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib AM_PART_APOLLO4P keil6
  c include: ../src;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../..;../../../../../../mcu/apollo4p/hal/mcu;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG;../../../../../../mcu/apollo4p/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx;../../../../../../mcu/apollo4p;../../../../../../utils;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../devices;../../../../bsp;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group ThinkSi_apollo4p_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group src
    ../src/: am_resources.c DejaVuSerif8pt1b.c DejaVuSerif8pt2b.c DejaVuSerif8pt4b.c DejaVuSerif8pt8b.c nemagfx_font_render.c simhei16pt1b.c simhei16pt2b.c simhei16pt4b.c simhei16pt8b.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_display_generic.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/keil6/bin/: lib_nema_apollo4p_nemagfx.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
