# IAR project uart_hci_bridge.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP330MPA-CBR AmbiqMicro AP330MPA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; apollo330mP_evb; AM_PACKAGE_BGA; AM_DEBUG_PRINTF; AM_FREERTOS; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO330P
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\open-amp\apps\ipc_service\backends; ..\..\..\..\..\..\third_party\open-amp\lib\include\internal; ..\..\..\..\..\..\third_party\open-amp\lib\include; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\portable\IAR\AMapollo5; ..\..\..\..\..\..\third_party\open-amp\lib\include\openamp; ..\..\..\..\..\..\third_party\open-amp\libmetal\lib\system\freertos\apollo330P; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\open-amp\lib\rpmsg; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\mcu\apollo330P\hal; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo330P; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\open-amp\apps\ipc_service\include\ipc; ..\..\..\..\..\..\third_party\open-amp; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\include; ..\src; ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: uart_hci_bridge.bin
  ILINK.IlinkOutputFile: uart_hci_bridge.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo330P\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; apollo330mP_evb; AM_PACKAGE_BGA; AM_DEBUG_PRINTF; AM_FREERTOS; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO330P
  group (top)
    ../../../../../../third_party/open-amp/apps/ipc_service/backends/: ipc_rpmsg_static_vrings.c
    ../../../../../../third_party/open-amp/libmetal/lib/: device.c dma.c init.c io.c irq.c log.c shmem.c softirq.c version.c
    ../../../../../../third_party/open-amp/libmetal/lib/system/freertos/: freertos_condition.c freertos_device.c freertos_init.c freertos_io.c freertos_irq.c freertos_mqueue.c freertos_shmem.c freertos_thread.c freertos_time.c
    ../../../../../../third_party/open-amp/lib/virtio/: virtio.c virtqueue.c
    ../../../../../../third_party/open-amp/lib/utils/: utilities.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/IAR/AMapollo5/: port.c portasm.s port_stimer.c port_systick_stimer.c
    ../../../../../../third_party/open-amp/libmetal/lib/system/freertos/apollo330P/: sys.c
    ../src/: am_resources.c ipc_tx_task.c main.c rtos.c uart_hci_bridge.c
    ../../../../../../third_party/open-amp/apps/ipc_service/: ipc_service.c
    ../../../../../../third_party/open-amp/apps/ipc_service/lib/: ipc_rpmsg.c ipc_static_vrings.c
    ../../../../../../third_party/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../devices/: am_devices_510L_radio.c
    ./: startup_iar.c
