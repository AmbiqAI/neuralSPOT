<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\ble_freertos_watch.ewp</path>
  </project>
  <batchBuild/>
</workspace>



