# Keil uVision project ble_freertos_eatt_watch.uvprojx, settings and files
target ble_freertos_eatt_watch (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: ble_freertos_eatt_watch
  AfterMake: fromelf --bin --output bin\ble_freertos_eatt_watch.bin bin\ble_freertos_eatt_watch.axf
  AfterMake: fromelf -cedrst --output bin\ble_freertos_eatt_watch.txt bin\ble_freertos_eatt_watch.axf
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: WSF_TRACE_ENABLED AM_BLE_EATT SEC_ECC_CFG=SEC_ECC_CFG_HCI AM_PART_APOLLO4P AM_FREERTOS AM_PACKAGE_BGA AM_DEBUG_PRINTF keil6
  c include: ../../../../../../devices;../../../../../../third_party/cordio/ble-profiles/sources/profiles/anpc;../../../../../../third_party/cordio/ble-profiles/sources/profiles/include;../../../../../../third_party/cordio/ble-profiles/sources/services;../../../../../../third_party/cordio/ble-profiles/sources/profiles/bas;../../../../../../third_party/cordio/ble-profiles/include/app;../../../../../../third_party/cordio/ble-host/include;../src;../../../../../../third_party/cordio/ble-profiles/sources/profiles/dis;../../../../../../third_party/cordio/ble-host/sources/stack/dm;../../../../../../third_party/cordio/ble-host/sources/stack/hci;../../../../../../third_party/cordio/ble-profiles/sources/profiles/hid;../../../../../../third_party/cordio/ble-profiles/sources/apps/watch;../../../../../../third_party/cordio/ble-profiles/sources/profiles/wdxs;../../../../../../third_party/uecc;../../../../../../third_party/cordio/ble-profiles/sources/profiles/paspc;../../../../../../third_party/FreeRTOSv10.5.1/Source/include;../../../../../../third_party/cordio/ble-host/sources/stack/smp;../../../../../../third_party/cordio/ble-profiles/sources/profiles/uribeacon;../../../../../../third_party/cordio/ble-host/sources/stack/cfg;../../../../../../third_party/cordio/ble-host/sources/hci/ambiq;../../../../bsp;../../../../../../third_party/cordio/ble-host/sources/stack/l2c;../../../../../../third_party/cordio/wsf/sources/util;../../../../../../third_party/cordio/ble-profiles/sources/apps;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo4;../../../../../../third_party/cordio/ble-profiles/sources/profiles;../../../../../../third_party/cordio/ble-profiles/sources/profiles/gap;../../../../../../third_party/cordio/ble-profiles/sources/profiles/gatt;../../../../../../third_party/cordio/ble-profiles/sources/apps/app;../../../../../../third_party/cordio/ble-host/sources/hci/ambiq/cooper;../../../../../..;../../../../../../mcu/apollo4p;../../../../../../third_party/cordio/wsf/sources/port/freertos;../../../../../../third_party/cordio/ble-host/sources/sec/common;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/cordio/wsf/sources;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/cordio/wsf/include;../../../../../../third_party/cordio/ble-profiles/sources/profiles/tipc;../../../../../../mcu/apollo4p/hal/mcu;../../../../../../utils;../../../../../../third_party/cordio/ble-host/sources/stack/att;../../../../../../third_party/cordio/ble-profiles/sources/profiles/hrpc
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group cordio_common
    ../../../../../../third_party/cordio/ble-profiles/sources/apps/app/common/: app_db.c app_hw.c app_ui.c ui_console.c ui_lcd.c ui_main.c ui_platform.c ui_timer.c
  group cordio_anpc
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/anpc/: anpc_main.c
  group cordio_l2c
    ../../../../../../third_party/cordio/ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
  group cordio_util
    ../../../../../../third_party/cordio/wsf/sources/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
  group FreeRTOSv10.5.1_AMapollo4
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo4/: port.c
  group cordio_att
    ../../../../../../third_party/cordio/ble-host/sources/stack/att/: attc_disc.c attc_eatt.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_eatt.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c att_eatt.c att_main.c att_uuid.c
  group cordio_gap
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/gap/: gap_main.c
  group cordio_bas
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/bas/: bas_main.c
  group cordio_gatt
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/gatt/: gatt_main.c
  group cordio_cooper
    ../../../../../../third_party/cordio/ble-host/sources/hci/ambiq/cooper/: hci_dbg_trc.c hci_drv_cooper.c hci_vs_cooper.c
  group src
    ../src/: am_resources.c ble_freertos_eatt_watch.c radio_task.c rtos.c
  group cordio_fmpl
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/fmpl/: fmpl_main.c
  group cordio_freertos
    ../../../../../../third_party/cordio/wsf/sources/port/freertos/: wsf_assert.c wsf_buf.c wsf_efs.c wsf_math.c wsf_msg.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
  group cordio_dis
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/dis/: dis_main.c
  group cordio_common
    ../../../../../../third_party/cordio/ble-host/sources/sec/common/: sec_aes.c sec_aes_rev.c sec_ccm_hci.c sec_cmac_hci.c sec_ecc_debug.c sec_ecc_hci.c sec_main.c
  group cordio_dm
    ../../../../../../third_party/cordio/ble-host/sources/stack/dm/: dm_adv.c dm_adv_ae.c dm_adv_leg.c dm_bis_master.c dm_bis_slave.c dm_cis.c dm_cis_master.c dm_cis_slave.c dm_cis_sm.c dm_conn.c dm_conn_cte.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_iso.c dm_main.c dm_past.c dm_phy.c dm_priv.c dm_scan.c dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
  group cordio_hci
    ../../../../../../third_party/cordio/ble-host/sources/stack/hci/: hci_main.c
  group cordio_hid
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/hid/: hid_main.c
  group cordio_watch
    ../../../../../../third_party/cordio/ble-profiles/sources/apps/watch/: watch_main.c
  group cordio_uecc
    ../../../../../../third_party/cordio/ble-host/sources/sec/uecc/: sec_ecc.c
  group uecc_uecc
    ../../../../../../third_party/uecc/: uECC.c uECC_ll.c
  group cordio_tipc
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/tipc/: tipc_main.c
  group cordio_paspc
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/paspc/: paspc_main.c
  group cordio_smp
    ../../../../../../third_party/cordio/ble-host/sources/stack/smp/: smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c smp_act.c smp_db.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c
  group cordio_cfg
    ../../../../../../third_party/cordio/ble-host/sources/stack/cfg/: cfg_stack.c
  group cordio_ambiq
    ../../../../../../third_party/cordio/ble-host/sources/hci/ambiq/: hci_cmd.c hci_cmd_ae.c hci_cmd_bis.c hci_cmd_cis.c hci_cmd_cte.c hci_cmd_iso.c hci_cmd_past.c hci_cmd_phy.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs_ae.c
  group cordio_hidapp
    ../../../../../../third_party/cordio/ble-profiles/sources/apps/hidapp/: hidapp_main.c
  group cordio_hrpc
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/hrpc/: hrpc_main.c
  group devices
    ../../../../../../devices/: am_devices_button.c am_devices_cooper.c am_devices_led.c
  group utils
    ../../../../../../utils/: am_util_ble_cooper.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group cordio_app
    ../../../../../../third_party/cordio/ble-profiles/sources/apps/app/: app_disc.c app_main.c app_master.c app_master_ae.c app_master_leg.c app_server.c app_slave.c app_slave_ae.c app_slave_leg.c app_terminal.c
  group cordio_services
    ../../../../../../third_party/cordio/ble-profiles/sources/services/: svc_alert.c svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_cte.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_time.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
