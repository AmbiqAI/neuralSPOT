# Keil uVision project mspi_octal_example.uvprojx, settings and files
target mspi_octal_example (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: mspi_octal_example
  AfterMake: fromelf --bin --output bin\mspi_octal_example.bin bin\mspi_octal_example.axf
  AfterMake: fromelf -cedrst --output bin\mspi_octal_example.txt bin\mspi_octal_example.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO4B apollo4b_evb_disp_shield AM_DEBUG_PRINTF AM_UTIL_FAULTISR_PRINT keil6
  c include: ../../../../bsp;../../../../../../devices;../src;../../../../../..;../../../../../../mcu/apollo4b;../../../../../../CMSIS/ARM/Include;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c mspi_octal_example.c
  group devices
    ../../../../../../devices/: am_devices_mspi_atxp032.c am_devices_mspi_is25wx064.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
