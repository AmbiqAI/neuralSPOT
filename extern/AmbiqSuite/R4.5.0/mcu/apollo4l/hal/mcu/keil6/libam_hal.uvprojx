# Keil uVision project libam_hal.uvprojx, settings and files
target libam_hal (ARM-ADS)
  device: AMAP42KL-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.0
  cpu: IROM(0x00018000,0x0001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: libam_hal (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO4L NEMA_PLATFORM=apollo4l_nemagfx APOLLO4L_PRE_SDK AM_DEBUG_ASSERT AM_ASSERT_INVALID_THRESHOLD=0 keil6
  c include: ../../../../../mcu/apollo4l/hal;../../../../../mcu/apollo4l;../../../../../third_party/ThinkSi/config/apollo4l_nemagfx;../../../../../CMSIS/AmbiqMicro/Include;../../../../../CMSIS/ARM/Include;../../../../../utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  group hal
    ../../../../../mcu/apollo4l/hal/: am_hal_access.c am_hal_adc.c am_hal_dcu.c am_hal_global.c am_hal_gpio.c am_hal_i2s.c am_hal_otp.c am_hal_pdm.c am_hal_pin.c am_hal_pwrctrl.c am_hal_queue.c am_hal_security.c am_hal_stimer.c am_hal_timer.c am_hal_wdt.c
  group mcu
    ../../../../../mcu/apollo4l/hal/mcu/: am_hal_bootrom_helper.c am_hal_cachectrl.c am_hal_card.c am_hal_card_host.c am_hal_clkgen.c am_hal_cmdq.c am_hal_fault.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mpu.c am_hal_mram.c am_hal_mspi.c am_hal_reset.c am_hal_rtc.c am_hal_sdhc.c am_hal_secure_ota.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_utils.c
