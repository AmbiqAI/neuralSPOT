# IAR project libam_bsp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; DSI_FREQ=AM_HAL_DSI_FREQ_TRIM_X20; DISP_CFG; DISP_TYPE=RM69330_DSI; NUM_LANES=1; AM_PART_APOLLO4P; B_USE_DPHYPLL=false; AM_PACKAGE_BGA; DBI_WIDTH=AM_HAL_DSI_DBI_WIDTH_16
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\devices; ..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\mcu\apollo4p; ..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\utils
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: libam_bsp.bin
  ILINK.IlinkOutputFile: libam_bsp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  group (top)
    ../: am_bsp.c am_bsp_pins.c
