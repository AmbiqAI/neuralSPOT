# IAR project ios_fullduplex.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP330MPA-CBR AmbiqMicro AP330MPA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PART_APOLLO330P; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\boards\apollo330mP_evb\bsp; ..\..\..\..\..\..\..\mcu\apollo330P; ..\..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\..; ..\..\common; ..\src; ..\..\..\..\..\..\..\utils; ..\..\..\..\..\..\..\devices; ..\..\..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ios_fullduplex.bin
  ILINK.IlinkOutputFile: ios_fullduplex.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\mcu\apollo330P\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\..\boards\apollo330mP_evb\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO330P; AM_PACKAGE_BGA
  group (top)
    ../../common/: ios_fullduplex_common.c
    ../src/: am_resources.c ios_fullduplex.c
    ../../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ./: startup_iar.c
