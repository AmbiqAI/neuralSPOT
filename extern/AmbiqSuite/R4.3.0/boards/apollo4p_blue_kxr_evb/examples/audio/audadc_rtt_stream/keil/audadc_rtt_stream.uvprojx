# Keil uVision project audadc_rtt_stream.uvprojx, settings and files
target audadc_rtt_stream (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: audadc_rtt_stream
  AfterMake: fromelf --bin --output bin\audadc_rtt_stream.bin bin\audadc_rtt_stream.axf
  AfterMake: fromelf -cedrst --output bin\audadc_rtt_stream.txt bin\audadc_rtt_stream.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO4P SEGGER_RTT_SECTION=\"SHARED_RW\" __FPU_PRESENT AM_PACKAGE_BGA AM_UTIL_FAULTISR_PRINT keil
  c include: ../../../../../../devices;../../../../../../CMSIS/ARM/Include;../../../../../../CMSIS/AmbiqMicro/Include;../src;../../../../../../mcu/apollo4p;../../../../bsp;../../../../../../utils;../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT;../../../../../..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c audadc_rtt_stream.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_led.c
  group SEGGER_RTT
    ../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
