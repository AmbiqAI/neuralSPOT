# IAR project apollo3_sec_bl_secure.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B2KK-KBR AmbiqMicro AMA3B2KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO3P; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\bsp; ..\..\..\..\..; ..\..\..\..\..\devices; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\mcu\apollo3p; ..\src; ..\..\..\..\..\third_party\mbedtls-2.4.2\include; ..\..\..\..\..\utils; ..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apollo3_sec_bl_secure.bin
  ILINK.IlinkOutputFile: apollo3_sec_bl_secure.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo3p\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO3P; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; AM_PACKAGE_BGA
  group (top)
    ../src/: apollo3_secbl.c apollo3_secbl_flash.c apollo3_secbl_image.c apollo3_secbl_info0.c apollo3_secbl_mspi_flash.c apollo3_secbl_secure.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../third_party/mbedtls-2.4.2/library/: aes.c md.c md_wrap.c memory_buffer_alloc.c platform.c sha256.c
    ../../../../../devices/: am_devices_mspi_atxp032.c
    ./: startup_iar.c
