# Keil uVision project systick_int.uvprojx, settings and files
target systick_int (ARM-ADS)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: systick_int
  AfterMake: fromelf --bin --output bin\systick_int.bin bin\systick_int.axf
  AfterMake: fromelf -cedrst --output bin\systick_int.txt bin\systick_int.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO3P AM_PACKAGE_BGA keil6
  c include: ../../../../../CMSIS/ARM/Include;../../../../..;../../../../../mcu/apollo3p;../../../bsp;../../../../../utils;../../../../../CMSIS/AmbiqMicro/Include;../../../../../devices;../src
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil6/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data) --undefined=__scatterload_copy
  group src
    ../src/: systick_int.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_led.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../mcu/apollo3p/hal/keil6/bin/: libam_hal.lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
