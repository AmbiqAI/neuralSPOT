# Keil uVision project tinyusb_cdc_msc_freertos.uvprojx, settings and files
target tinyusb_cdc_msc_freertos (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: tinyusb_cdc_msc_freertos
  AfterMake: fromelf --bin --output bin\tinyusb_cdc_msc_freertos.bin bin\tinyusb_cdc_msc_freertos.axf
  AfterMake: fromelf -cedrst --output bin\tinyusb_cdc_msc_freertos.txt bin\tinyusb_cdc_msc_freertos.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_TUSB_DEBUG=2 AM_PACKAGE_BGA AM_PART_APOLLO4B CFG_TUSB_MCU=OPT_MCU_APOLLO4 BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED apollo4b_evb AM_FREERTOS keil
  c include: ../src;../../../../bsp;../../../../../../mcu/apollo4b;../../../../../../third_party/tinyusb/source/src/osal;../../../../../../third_party/tinyusb/source/src/common;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil/AMapollo4;../../../../../../devices;../../../../../../third_party/tinyusb/source/src;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../utils;../../../../../../third_party/tinyusb/source/src/class/msc;../../../../../../third_party/tinyusb/source/src/class/cdc;../../../../../../third_party/FreeRTOSv10.5.1/Source/include;../../../../../../mcu/apollo4b/hal
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib
  group tinyusb_apollo4
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
  group src
    ../src/: am_resources.c apollo4_board.c freertos_hook.c msc_disk.c rtos.c tinyusb_cdc_msc_freertos.c usb_descriptors.c
  group tinyusb_common
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
  group tinyusb_device
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
  group FreeRTOSv10.5.1_AMapollo4
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil/AMapollo4/: port.c
  group tinyusb_src
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group tinyusb_msc
    ../../../../../../third_party/tinyusb/source/src/class/msc/: msc_device.c
  group tinyusb_cdc
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
