# Keil uVision project nemagfx_gauge.uvprojx, settings and files
target nemagfx_gauge (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_gauge
  AfterMake: fromelf --bin --output bin\nemagfx_gauge.bin bin\nemagfx_gauge.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_gauge.txt bin\nemagfx_gauge.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO4B NEMA_PLATFORM=apollo4b_nemagfx AM_FREERTOS NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK USE_NEMAGUI_LIB LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib USE_TSI_MALLOC ENABLE_TE CALCULATE_FPS keil
  c include: ../../../../../..;../../../../../../devices;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../src/generated/NemaGUI/include/gitems;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../src/generated;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../CMSIS/ARM/Include;../../../../bsp;../src/generated/NemaGUI/include;../../../../../../mcu/apollo4b;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4b/hal;../../../../../../mcu/apollo4b/hal/mcu;../src/generated/assets/images;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil/AMapollo4;../src/generated/assets/fonts;../src;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../utils;../../../../../../third_party/FreeRTOSv10.5.1/Source/include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib
  group src
    ../src/: am_resources.c gui_task.c nemagfx_gauge.c nemagui_porting.c rtos.c
  group FreeRTOSv10.5.1_AMapollo4
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil/AMapollo4/: port.c
  group generated
    ../src/generated/: custom_callbacks.c event_list.c fonts.c framebuffers.c gui_tree.c images.c main.c screen_groups.c
  group ThinkSi_apollo4b_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group devices
    ../../../../../../devices/: am_devices_display_generic.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/keil/bin/: lib_nema_apollo4b_nemagfx.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../third_party/NemaGUI/config/apollo4b/keil/bin/: NemaGUI.lib
