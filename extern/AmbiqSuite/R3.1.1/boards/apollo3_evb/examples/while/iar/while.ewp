# IAR project while.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PRINTF_BUFSIZE=256; AM_PART_APOLLO3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\devices; ..\..\..\bsp; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\utils; ..\src; ..\..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: while.bin
  ILINK.IlinkOutputFile: while.out
  ILINK.IlinkIcfFile: while.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PRINTF_BUFSIZE=256; AM_PART_APOLLO3
  group (top)
    ../src/: while.c
    ../../../../../utils/: am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
