# IAR project nemagfx_vg_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; USE_TSI_MALLOC; VMEM_BASEADDR=0x10060400; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; VMEM_SIZE=0x180000; APS25616N_OCTAL_MODE_EN; BAREMETAL; AM_UTIL_FAULTISR_PRINT; apollo4p_evb_disp_shield_rev2; PLATFORM=apollo4p_nemagfx; ENABLE_TE; RUN_IN_HP_MODE; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; DEBUG_PIN=74; AM_PACKAGE_BGA; AM_PART_APOLLO4P
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\mcu\apollo4p\hal; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\src; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4p_nemagfx; ..\..\..\..\..\..; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\bsp; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaVG; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_vg_test.bin
  ILINK.IlinkOutputFile: nemagfx_vg_test.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4p_nemagfx\iar\bin\lib_nema_apollo4p_nemagfx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; USE_TSI_MALLOC; VMEM_BASEADDR=0x10060400; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; VMEM_SIZE=0x180000; APS25616N_OCTAL_MODE_EN; BAREMETAL; AM_UTIL_FAULTISR_PRINT; apollo4p_evb_disp_shield_rev2; PLATFORM=apollo4p_nemagfx; ENABLE_TE; RUN_IN_HP_MODE; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; DEBUG_PIN=74; AM_PACKAGE_BGA; AM_PART_APOLLO4P
  group (top)
    ../src/text_transformation/: text_transformation.c
    ../src/masking_example/: masking_example.c
    ../src/paint_lut_example/: paint_lut_example.c
    ../src/: am_resources.c display.c nemagfx_vg_test.c psram.c
    ../src/tsvg_render_example/: Arial_ttf.c tsvg_render_example.c
    ../src/render_vg_font/: render_vg_font.c
    ../src/shapes/: shapes.c
    ../src/paint_example/: paint_example.c
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../src/tsvg_benchmark/: tsvg_benchmark.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_nemadc_rm67162.c
    ./: startup_iar.c
