# IAR project uart_ble_bridge.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO4P; BLE_BRIDGE_SINGLE_MODE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\mcu\apollo4p\hal\mcu; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\..\..\..\..\..\third_party\cordio\wsf\include; ..\src; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\ambiq_ble\apps\dtm_module; ..\..\..\..\..\..; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\cordio\wsf\sources\port\freertos; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\cordio\ble-host\sources\hci\ambiq\cooper
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: uart_ble_bridge.bin
  ILINK.IlinkOutputFile: uart_ble_bridge.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO4P; BLE_BRIDGE_SINGLE_MODE
  group (top)
    ../src/: am_resources.c uart_ble_bridge.c
    ../../../../../../ambiq_ble/apps/dtm_module/: dtm_main.c
    ../../../../../../devices/: am_devices_cooper.c
    ../../../../../../utils/: am_util_ble_cooper.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
