# IAR project ios_fifo_host.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO4P
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\src; ..\..\..\..\..\..; ..\..\..\..\..\..\devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ios_fifo_host.bin
  ILINK.IlinkOutputFile: ios_fifo_host.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO4P
  group (top)
    ../src/: am_resources.c ios_fifo_host.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ./: startup_iar.c
