# Keil uVision project nemagfx_vg_test.uvprojx, settings and files
target nemagfx_vg_test (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_vg_test
  AfterMake: fromelf --bin --output bin\nemagfx_vg_test.bin bin\nemagfx_vg_test.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_vg_test.txt bin\nemagfx_vg_test.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_TSI_MALLOC VMEM_BASEADDR=0x10060400 LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib VMEM_SIZE=0x180000 APS25616N_OCTAL_MODE_EN BAREMETAL AM_UTIL_FAULTISR_PRINT apollo4p_evb_disp_shield_rev2 PLATFORM=apollo4p_nemagfx ENABLE_TE RUN_IN_HP_MODE NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK DEBUG_PIN=74 AM_PACKAGE_BGA AM_PART_APOLLO4P keil
  c include: ../../../../../../mcu/apollo4p/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../src;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx;../../../../../..;../../../../../../CMSIS/ARM/Include;../../../../bsp;../../../../../../utils;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../mcu/apollo4p;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../devices;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group text_transformation
    ../src/text_transformation/: text_transformation.c
  group masking_example
    ../src/masking_example/: masking_example.c
  group paint_lut_example
    ../src/paint_lut_example/: paint_lut_example.c
  group src
    ../src/: am_resources.c display.c nemagfx_vg_test.c psram.c
  group tsvg_render_example
    ../src/tsvg_render_example/: Arial_ttf.c tsvg_render_example.c
  group render_vg_font
    ../src/render_vg_font/: render_vg_font.c
  group shapes
    ../src/shapes/: shapes.c
  group paint_example
    ../src/paint_example/: paint_example.c
  group ThinkSi_apollo4p_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group tsvg_benchmark
    ../src/tsvg_benchmark/: tsvg_benchmark.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_nemadc_rm67162.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/keil/bin/: lib_nema_apollo4p_nemagfx.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
