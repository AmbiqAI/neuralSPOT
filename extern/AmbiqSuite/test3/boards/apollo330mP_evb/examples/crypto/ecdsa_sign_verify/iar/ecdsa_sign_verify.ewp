# IAR project ecdsa_sign_verify.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP330MPA-CBR AmbiqMicro AP330MPA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; CC_IOT; AM_PART_APOLLO330P; AM_PACKAGE_BGA; AM_HAL_SKIP_NO_MVE_WARNING; AM_UTIL_FAULTISR_PRINT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\crypto\shared\include\pal; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\devices; ..\..\..\..\bsp; ..\..\..\..\..\..\mcu\apollo330P; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\crypto\shared\include\pal\no_os; ..\src; ..\..\..\..\..\..\third_party\crypto\host\include; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\crypto\mbedtls\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ecdsa_sign_verify.bin
  ILINK.IlinkOutputFile: ecdsa_sign_verify.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo330P\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedtls-m55.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libcc_312-m55.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libpal_no_os-m55.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedcrypto-m55.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; CC_IOT; AM_PART_APOLLO330P; AM_PACKAGE_BGA; AM_HAL_SKIP_NO_MVE_WARNING; AM_UTIL_FAULTISR_PRINT
  group (top)
    ../src/: am_resources.c ecdsa_sign_verify.c
    ../../../../../../utils/: am_util_crypto.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
