# Keil uVision project rsa_sign_verify.uvprojx, settings and files
target rsa_sign_verify (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: rsa_sign_verify
  AfterMake: fromelf --bin --output bin\rsa_sign_verify.bin bin\rsa_sign_verify.axf
  AfterMake: fromelf -cedrst --output bin\rsa_sign_verify.txt bin\rsa_sign_verify.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_UTIL_FAULTISR_PRINT AM_PACKAGE_BGA AM_PART_APOLLO4P CC_IOT keil
  c include: ../../../../../../CMSIS/ARM/Include;../../../../../../utils;../../../../../../third_party/crypto/shared/include/pal/no_os;../../../../../../mcu/apollo4p;../../../../../..;../../../../bsp;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/crypto/host/include;../../../../../../devices;../../../../../../third_party/crypto/mbedtls/include;../../../../../../third_party/crypto/shared/include/pal;../src
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib
  group src
    ../src/: am_resources.c rsa_sign_verify.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../third_party/crypto/mbedtls/library/: cryptombedtls.lib
    ../../../../../../third_party/crypto/host/lib/: libpal_no_os.lib libcc_312.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
