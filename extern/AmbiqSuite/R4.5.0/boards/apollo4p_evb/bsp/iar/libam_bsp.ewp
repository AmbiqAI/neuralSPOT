# IAR project libam_bsp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO4P; B_USE_DPHYPLL=true; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\devices; ..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\utils; ..\..\..\..\mcu\apollo4p; ..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: libam_bsp.bin
  ILINK.IlinkOutputFile: libam_bsp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  group (top)
    ../: am_bsp.c am_bsp_pins.c
