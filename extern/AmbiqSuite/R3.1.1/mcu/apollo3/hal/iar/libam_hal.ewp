# IAR project libam_hal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO3; AM_ASSERT_INVALID_THRESHOLD=0; AM_DEBUG_ASSERT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\mcu\apollo3
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: libam_hal.bin
  ILINK.IlinkOutputFile: libam_hal.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  group (top)
    ../: am_hal_adc.c am_hal_ble.c am_hal_ble_patch.c am_hal_ble_patch_b0.c am_hal_burst.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_cmdq.c am_hal_ctimer.c am_hal_debug.c am_hal_entropy.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mspi.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_scard.c am_hal_secure_ota.c am_hal_security.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_wdt.c
