# Keil uVision project rng_puf_test.uvprojx, settings and files
target rng_puf_test (6160000::V6.16::ARMCLANG)
  device: AP330MPA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.4
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: rng_puf_test
  AfterMake: fromelf --bin --output bin\rng_puf_test.bin bin\rng_puf_test.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AM_PART_APOLLO330P AM_UTIL_FAULTISR_PRINT AM_PACKAGE_BGA AM_DEBUG_PRINTF keil6
  c include: ../../../../../..;../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo330P;../../../../../../mcu/apollo330P/hal;../../../../bsp;../src;../../../../../../mcu/apollo330P/hal/mcu;../../../../../../utils;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../devices
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo330P/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c rng_puf_test.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../../../mcu/apollo330P/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
software components: Device:Startup 1.1.0
