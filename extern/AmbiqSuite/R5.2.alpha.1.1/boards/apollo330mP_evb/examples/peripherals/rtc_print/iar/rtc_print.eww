<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\rtc_print.ewp</path>
  </project>
  <batchBuild/>
</workspace>



