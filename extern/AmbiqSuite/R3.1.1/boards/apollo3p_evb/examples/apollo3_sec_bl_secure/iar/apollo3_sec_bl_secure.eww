<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\apollo3_sec_bl_secure.ewp</path>
  </project>
  <batchBuild/>
</workspace>



