<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\ios_lram.ewp</path>
  </project>
  <batchBuild/>
</workspace>



