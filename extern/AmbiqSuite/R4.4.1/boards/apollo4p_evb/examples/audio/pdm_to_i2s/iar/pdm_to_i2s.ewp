# IAR project pdm_to_i2s.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; UNITY_INCLUDE_CONFIG_H; __FPU_PRESENT; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO4P; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\ARM\Include; ..\src; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\SEGGER\SEGGER_RTT_V680a\RTT; ..\..\..\..\..\..\utils
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: pdm_to_i2s.bin
  ILINK.IlinkOutputFile: pdm_to_i2s.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\CMSIS\ARM\Lib\ARM\iar_cortexM4lf_math.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; UNITY_INCLUDE_CONFIG_H; __FPU_PRESENT; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO4P; AM_PACKAGE_BGA
  group (top)
    ../src/: am_resources.c pdm_to_i2s.c
    ../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
