# IAR project while.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KL-KBR AmbiqMicro AMAP42KL-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO4L; AM_PRINTF_BUFSIZE=256; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\ARM\Include; ..\src; ..\..\..\..\bsp; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..; ..\..\..\..\..\..\mcu\apollo4l; ..\..\..\..\..\..\utils
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: while.bin
  ILINK.IlinkOutputFile: while.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4l\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO4L; AM_PRINTF_BUFSIZE=256; AM_PACKAGE_BGA
  group (top)
    ../src/: am_resources.c while.c
    ../../../../../../utils/: am_util_stdio.c
    ./: startup_iar.c
