# Keil uVision project tinyusb_hid_generic.uvprojx, settings and files
target tinyusb_hid_generic (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: tinyusb_hid_generic
  AfterMake: fromelf --bin --output bin\tinyusb_hid_generic.bin bin\tinyusb_hid_generic.axf
  AfterMake: fromelf -cedrst --output bin\tinyusb_hid_generic.txt bin\tinyusb_hid_generic.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: CFG_TUSB_MCU=OPT_MCU_APOLLO4 apollo4p_blue_kbr_evb AM_PART_APOLLO4P CFG_TUSB_DEBUG=2 AM_PACKAGE_BGA BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED keil6
  c include: ../../../../../../third_party/tinyusb/source/src/class/hid;../../../../../../utils;../../../../../../mcu/apollo4p/hal;../../../../../../devices;../../../../../../third_party/tinyusb/source/src;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/tinyusb/source/src/common;../src;../../../../bsp;../../../../../../third_party/tinyusb/source/src/osal;../../../../../..;../../../../../../mcu/apollo4p;../../../../../../CMSIS/AmbiqMicro/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group tinyusb_common
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
  group src
    ../src/: am_resources.c apollo4_board.c tinyusb_hid_generic.c usb_descriptors.c
  group tinyusb_apollo4
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
  group tinyusb_src
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
  group tinyusb_device
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
  group tinyusb_hid
    ../../../../../../third_party/tinyusb/source/src/class/hid/: hid_device.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
