# Keil uVision project nemagfx_vg_ttf.uvprojx, settings and files
target nemagfx_vg_ttf (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_vg_ttf
  AfterMake: fromelf --bin --output bin\nemagfx_vg_ttf.bin bin\nemagfx_vg_ttf.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_vg_ttf.txt bin\nemagfx_vg_ttf.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_FREERTOS apollo4p_evb_disp_shield_rev2 VMEM_SIZE=0x180000 PLATFORM=apollo4p_nemagfx NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK AM_UTIL_FAULTISR_PRINT USE_TSI_MALLOC AM_PACKAGE_BGA AM_PART_APOLLO4P APS25616N_OCTAL_MODE_EN VMEM_BASEADDR=0x10060400 RUN_IN_HP_MODE ENABLE_TE LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib keil
  c include: ../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../third_party/FreeRTOSv10.1.1/Source/include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo4;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG;../../../../../../devices;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4p/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../CMSIS/ARM/Include;../src;../../../../bsp;../../../../../../utils;../../../../../../mcu/apollo4p;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c display_task.c graphics_power_control.c gui_task.c nemagfx_vg_ttf.c psram.c render_task.c rtos.c
  group FreeRTOSv10.1.1_AMapollo4
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo4/: port.c
  group ThinkSi_apollo4p_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group devices
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_nemadc_rm67162.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
  group FreeRTOSv10.1.1_Source
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group font
    ../src/font/: DejaVuSans_ttf_kern.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/keil/bin/: lib_nema_apollo4p_nemagfx.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
