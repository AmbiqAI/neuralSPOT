# Keil uVision project libam_bsp.uvprojx, settings and files
target libam_bsp (ARM-ADS)
  device: AMAP42KL-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.0
  cpu: IROM(0x00018000,0x0001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: libam_bsp (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO4L NEMA_PLATFORM=apollo4l_nemagfx keil6
  c include: ../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../CMSIS/AmbiqMicro/Include;../../../../third_party/ThinkSi/config/apollo4l_nemagfx;../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../devices;../../../../CMSIS/ARM/Include;../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../utils;../../../../mcu/apollo4l;../../../../mcu/apollo4l/hal;../../../../mcu/apollo4l/hal/mcu
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  group source_files
    ../: am_bsp.c am_bsp_pins.c
