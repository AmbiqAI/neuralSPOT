# IAR project mspi_ddr_octal_psram_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_UTIL_FAULTISR_PRINT; APS12808L; AM_PACKAGE_BGA; AM_PART_APOLLO4B
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\..; ..\..\..\..\bsp; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mspi_ddr_octal_psram_example.bin
  ILINK.IlinkOutputFile: mspi_ddr_octal_psram_example.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_UTIL_FAULTISR_PRINT; APS12808L; AM_PACKAGE_BGA; AM_PART_APOLLO4B
  group (top)
    ../src/: am_resources.c mspi_ddr_octal_psram_example.c
    ../../../../../../devices/: am_devices_mspi_psram_aps12808l.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
