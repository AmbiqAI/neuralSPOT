# Keil uVision project while.uvprojx, settings and files
target while (ARM-ADS)
  device: AMAP42KL-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.0
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: while
  AfterMake: fromelf --bin --output bin\while.bin bin\while.axf
  AfterMake: fromelf -cedrst --output bin\while.txt bin\while.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO4L AM_PRINTF_BUFSIZE=256 AM_PACKAGE_BGA keil
  c misc: --reduce_paths
  c include: ../../../../../../CMSIS/ARM/Include;../src;../../../../bsp;../../../../../../devices;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../..;../../../../../../mcu/apollo4l;../../../../../../utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4l/hal/mcu/keil/bin/libam_hal.lib
  group src
    ../src/: am_resources.c while.c
  group utils
    ../../../../../../utils/: am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4l/hal/mcu/keil/bin/: libam_hal.lib
