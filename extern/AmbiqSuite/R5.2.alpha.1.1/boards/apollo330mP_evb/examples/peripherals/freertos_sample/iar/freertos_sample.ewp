# IAR project freertos_sample.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP330MPA-CBR AmbiqMicro AP330MPA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_UTIL_FAULTISR_PRINT; AM_FREERTOS; AM_PACKAGE_BGA; AM_PART_APOLLO330P
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\portable\IAR\AMapollo5; ..\..\..\..\..\..\mcu\apollo330P\hal\mcu; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\include; ..\src; ..\..\..\..\..\..\mcu\apollo330P\hal; ..\..\..\..\bsp; ..\..\..\..\..\..\devices; ..\..\..\..\..\..; ..\..\..\..\..\..\mcu\apollo330P; ..\..\..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sample.bin
  ILINK.IlinkOutputFile: freertos_sample.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo330P\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_UTIL_FAULTISR_PRINT; AM_FREERTOS; AM_PACKAGE_BGA; AM_PART_APOLLO330P
  group (top)
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/IAR/AMapollo5/: port.c portasm.s port_stimer.c port_systick_stimer.c
    ../src/: am_resources.c freertos_sample.c hello_task.c print_task.c rtos.c timer_task.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
    ./: startup_iar.c
