# IAR project mspi_aps25616ba_1p2v_psram_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP330MPA-CBR AmbiqMicro AP330MPA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PART_APOLLO330P; apollo330mP_evb; APS25616BA; MSPI_PSRAM_HEX_MODE; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT; AM_DEBUG_PRINTF
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..; ..\..\..\..\..\..\utils; ..\src; ..\..\..\..\..\..\mcu\apollo330P; ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mspi_aps25616ba_1p2v_psram_example.bin
  ILINK.IlinkOutputFile: mspi_aps25616ba_1p2v_psram_example.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo330P\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO330P; apollo330mP_evb; APS25616BA; MSPI_PSRAM_HEX_MODE; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT; AM_DEBUG_PRINTF
  group (top)
    ../src/: am_resources.c mspi_aps25616ba_1p2v_psram_example.c
    ../../../../../../devices/: am_devices_mspi_psram_aps25616ba_1p2v.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
