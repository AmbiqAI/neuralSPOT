# IAR project libam_hal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP54KK-KBR  AmbiqMicro AMAP54KK-KBR
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_DEFAULT_RSS_BASE_ADDR=0x00500000; AM_PART_APOLLO510L; AM_DEBUG_ASSERT; AM_ASSERT_INVALID_THRESHOLD=0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\third_party\ThinkSi\config\apollo510L_nemagfx; ..\..\..\..\..\utils; ..\..\..\..\..\mcu\apollo510L; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\mcu\apollo510L\hal; ..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: libam_hal.bin
  ILINK.IlinkOutputFile: libam_hal.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 4
  group (top)
    ../../../../../mcu/apollo510L/hal/mcu/: am_hal_bootrom_helper.c am_hal_cachectrl.c am_hal_card.c am_hal_card_host.c am_hal_clkgen.c am_hal_cmdq.c am_hal_crm.c am_hal_debug.c am_hal_dsi.c am_hal_i3c.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mpu.c am_hal_mram.c am_hal_mram_recovery.c am_hal_mspi.c am_hal_reset.c am_hal_rtc.c am_hal_sdhc.c am_hal_secure_ota.c am_hal_sysctrl.c am_hal_syspll.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_uart_stream.c am_hal_utils.c
    ../../../../../mcu/apollo510L/hal/: am_hal_access.c am_hal_adc.c am_hal_clkmgr.c am_hal_dcu.c am_hal_global.c am_hal_gpio.c am_hal_i2s.c am_hal_info.c am_hal_infoc.c am_hal_ipc_mbox.c am_hal_pdm.c am_hal_pin.c am_hal_pwrctrl.c am_hal_queue.c am_hal_security.c am_hal_spotmgr.c am_hal_spotmgr_trimver_1.c am_hal_spotmgr_trimver_2.c am_hal_stimer.c am_hal_timer.c am_hal_usb.c am_hal_vcomp.c am_hal_wdt.c
