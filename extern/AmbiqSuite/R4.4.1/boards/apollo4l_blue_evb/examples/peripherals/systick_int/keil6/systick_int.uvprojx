# Keil uVision project systick_int.uvprojx, settings and files
target systick_int (ARM-ADS)
  device: AMAP42KL-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.0
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: systick_int
  AfterMake: fromelf --bin --output bin\systick_int.bin bin\systick_int.axf
  AfterMake: fromelf -cedrst --output bin\systick_int.txt bin\systick_int.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PRINTF_BUFSIZE=256 AM_PART_APOLLO4L AM_PACKAGE_BGA keil6
  c include: ../../../../bsp;../../../../../..;../../../../../../CMSIS/ARM/Include;../src;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4l;../../../../../../devices;../../../../../../utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4l/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c systick_int.c
  group devices
    ../../../../../../devices/: am_devices_led.c
  group utils
    ../../../../../../utils/: am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4l/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
