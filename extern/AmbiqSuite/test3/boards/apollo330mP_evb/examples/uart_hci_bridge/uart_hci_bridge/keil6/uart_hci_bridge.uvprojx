# Keil uVision project uart_hci_bridge.uvprojx, settings and files
target uart_hci_bridge (6160000::V6.16::ARMCLANG)
  device: AP330MPA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.4
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: uart_hci_bridge
  AfterMake: fromelf --bin --output bin\uart_hci_bridge.bin bin\uart_hci_bridge.axf
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: apollo330mP_evb AM_PACKAGE_BGA AM_DEBUG_PRINTF AM_FREERTOS AM_UTIL_FAULTISR_PRINT AM_PART_APOLLO330P keil6
  c include: ../../../../../../third_party/open-amp/apps/ipc_service/backends;../../../../../../third_party/open-amp/lib/include/internal;../../../../../../third_party/open-amp/lib/include;../../../../../../third_party/open-amp/lib/include/openamp;../../../../../../third_party/open-amp/libmetal/lib/system/freertos/apollo330P;../../../../../..;../../../../../../third_party/open-amp/lib/rpmsg;../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo330P/hal;../../../../../../devices;../../../../../../mcu/apollo330P;../../../../../../utils;../../../../../../third_party/open-amp/apps/ipc_service/include/ipc;../../../../../../third_party/open-amp;../../../../../../third_party/FreeRTOSv10.5.1/Source/include;../src;../../../../bsp;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo5
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo330P/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group open-amp_backends
    ../../../../../../third_party/open-amp/apps/ipc_service/backends/: ipc_rpmsg_static_vrings.c
  group open-amp_lib
    ../../../../../../third_party/open-amp/libmetal/lib/: device.c dma.c init.c io.c irq.c log.c shmem.c softirq.c version.c
  group open-amp_freertos
    ../../../../../../third_party/open-amp/libmetal/lib/system/freertos/: freertos_condition.c freertos_device.c freertos_init.c freertos_io.c freertos_irq.c freertos_mqueue.c freertos_shmem.c freertos_thread.c freertos_time.c
  group open-amp_virtio
    ../../../../../../third_party/open-amp/lib/virtio/: virtio.c virtqueue.c
  group open-amp_utils
    ../../../../../../third_party/open-amp/lib/utils/: utilities.c
  group open-amp_apollo330P
    ../../../../../../third_party/open-amp/libmetal/lib/system/freertos/apollo330P/: sys.c
  group src
    ../src/: am_resources.c ipc_tx_task.c main.c rtos.c uart_hci_bridge.c
  group open-amp_ipc_service
    ../../../../../../third_party/open-amp/apps/ipc_service/: ipc_service.c
  group open-amp_lib
    ../../../../../../third_party/open-amp/apps/ipc_service/lib/: ipc_rpmsg.c ipc_static_vrings.c
  group open-amp_rpmsg
    ../../../../../../third_party/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c
  group FreeRTOSv10.5.1_AMapollo5
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo5/: port.c portasm.c port_stimer.c port_systick_stimer.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group utils
    ../../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group devices
    ../../../../../../devices/: am_devices_510L_radio.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../../../mcu/apollo330P/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
software components: Device:Startup 1.1.0
