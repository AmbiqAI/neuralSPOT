# Keil uVision project ios_fifo_host.uvprojx, settings and files
target ios_fifo_host (ARM-ADS)
  device: AMAP42KL-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.0
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: ios_fifo_host
  AfterMake: fromelf --bin --output bin\ios_fifo_host.bin bin\ios_fifo_host.axf
  AfterMake: fromelf -cedrst --output bin\ios_fifo_host.txt bin\ios_fifo_host.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO4L keil
  c misc: --reduce_paths
  c include: ../../../../../..;../src;../../../../bsp;../../../../../../mcu/apollo4l;../../../../../../devices;../../../../../../CMSIS/ARM/Include;../../../../../../utils;../../../../../../CMSIS/AmbiqMicro/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4l/hal/mcu/keil/bin/libam_hal.lib
  group src
    ../src/: am_resources.c ios_fifo_host.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4l/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
