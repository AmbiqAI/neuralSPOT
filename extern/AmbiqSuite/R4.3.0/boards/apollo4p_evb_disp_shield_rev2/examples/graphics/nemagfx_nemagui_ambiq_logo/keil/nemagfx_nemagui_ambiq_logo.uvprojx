# Keil uVision project nemagfx_nemagui_ambiq_logo.uvprojx, settings and files
target nemagfx_nemagui_ambiq_logo (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_nemagui_ambiq_logo
  AfterMake: fromelf --bin --output bin\nemagfx_nemagui_ambiq_logo.bin bin\nemagfx_nemagui_ambiq_logo.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_nemagui_ambiq_logo.txt bin\nemagfx_nemagui_ambiq_logo.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_TSI_MALLOC SCENARIO_C WALL_TIME_CLOCKS ASSET_LOCATE_IN_PSRAM AM_PACKAGE_BGA LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib AM_FREERTOS CALCULATE_FPS PLATFORM=apollo4p_nemagfx NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK USE_TOUCH AM_PART_APOLLO4P ENABLE_TE keil
  c include: ../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../mcu/apollo4p;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../bsp;../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo4;../src/generated;../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo4p/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../utils;../src/generated/assets/images;../src/generated/assets/fonts;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../src/generated/NemaGUI/include;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../src/generated/NemaGUI/include/gitems;../../../../../../third_party/FreeRTOSv10.1.1/Source/include;../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx;../../../../../../devices;../src;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group ThinkSi_apollo4p_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group src
    ../src/: am_resources.c gui_task.c nemagfx_nemagui_ambiq_logo.c psram_malloc.c rtos.c
  group FreeRTOSv10.1.1_AMapollo4
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo4/: port.c
  group generated
    ../src/generated/: custom_callbacks.c event_list.c fonts.c framebuffers.c gui_tree.c images.c main.c screen_groups.c
  group FreeRTOSv10.1.1_Source
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_mspi_psram_aps12808l.c am_devices_mspi_psram_aps25616n.c am_devices_nemadc_rm67162.c am_devices_tma525.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/keil/bin/: lib_nema_apollo4p_nemagfx.lib
    ../../../../../../third_party/NemaGUI/config/apollo4p/keil/bin/: NemaGUI.lib
