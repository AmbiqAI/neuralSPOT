# IAR project rng_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO4P; CC_IOT; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\crypto\shared\include\pal\no_os; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\bsp; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\third_party\crypto\host\include; ..\src; ..\..\..\..\..\..\third_party\crypto\shared\include\pal; ..\..\..\..\..\..\third_party\crypto\mbedtls\include; ..\..\..\..\..\..\devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rng_test.bin
  ILINK.IlinkOutputFile: rng_test.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libpal_no_os.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedcrypto.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedtls.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libcc_312.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO4P; CC_IOT; AM_PACKAGE_BGA
  group (top)
    ../src/: am_resources.c rng_test.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
