# IAR project ble_firmware_update.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO4P
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\cordio\ble-host\sources\hci\ambiq\cooper; ..\..\..\..\..\..\utils; ..\..\..\..\bsp; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\mcu\apollo4p\hal\mcu; ..\..\..\..\..\..; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\src; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_firmware_update.bin
  ILINK.IlinkOutputFile: ble_firmware_update.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO4P
  group (top)
    ../src/: am_resources.c ble_firmware_update.c
    ../../../../../../utils/: am_util_ble_cooper.c am_util_delay.c am_util_stdio.c
    ../../../../../../devices/: am_devices_cooper.c
    ./: startup_iar.c
