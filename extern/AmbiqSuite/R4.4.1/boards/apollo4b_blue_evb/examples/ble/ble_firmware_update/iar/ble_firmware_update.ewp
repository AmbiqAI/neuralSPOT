# IAR project ble_firmware_update.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO4B; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\src; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\cordio\ble-host\sources\hci\ambiq\cooper; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_firmware_update.bin
  ILINK.IlinkOutputFile: ble_firmware_update.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO4B; AM_PACKAGE_BGA
  group (top)
    ../src/: am_resources.c ble_firmware_update.c
    ../../../../../../utils/: am_util_ble_cooper.c am_util_delay.c am_util_stdio.c
    ../../../../../../devices/: am_devices_cooper.c
    ./: startup_iar.c
