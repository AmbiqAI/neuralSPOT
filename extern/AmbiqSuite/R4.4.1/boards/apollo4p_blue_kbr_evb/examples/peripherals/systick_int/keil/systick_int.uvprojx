# Keil uVision project systick_int.uvprojx, settings and files
target systick_int (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: systick_int
  AfterMake: fromelf --bin --output bin\systick_int.bin bin\systick_int.axf
  AfterMake: fromelf -cedrst --output bin\systick_int.txt bin\systick_int.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO4P AM_PACKAGE_BGA AM_PRINTF_BUFSIZE=256 keil
  c include: ../../../../../../devices;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4p;../../../../../../CMSIS/ARM/Include;../../../../bsp;../../../../../../utils;../src
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib
  group src
    ../src/: am_resources.c systick_int.c
  group devices
    ../../../../../../devices/: am_devices_led.c
  group utils
    ../../../../../../utils/: am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
