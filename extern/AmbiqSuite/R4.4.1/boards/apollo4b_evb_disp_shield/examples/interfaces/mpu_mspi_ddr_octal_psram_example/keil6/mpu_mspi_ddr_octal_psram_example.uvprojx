# Keil uVision project mpu_mspi_ddr_octal_psram_example.uvprojx, settings and files
target mpu_mspi_ddr_octal_psram_example (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: mpu_mspi_ddr_octal_psram_example
  AfterMake: fromelf --bin --output bin\mpu_mspi_ddr_octal_psram_example.bin bin\mpu_mspi_ddr_octal_psram_example.axf
  AfterMake: fromelf -cedrst --output bin\mpu_mspi_ddr_octal_psram_example.txt bin\mpu_mspi_ddr_octal_psram_example.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO4B AM_UTIL_FAULTISR_PRINT AM_PACKAGE_BGA AM_DEBUG_PRINTF APS12808L keil6
  c include: ../../../../../../devices;../../../../../../CMSIS/AmbiqMicro/Include;../src;../../../../../../CMSIS/ARM/Include;../../../../../../utils;../../../../../../mcu/apollo4b;../../../../../..;../../../../bsp
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c mpu_mspi_ddr_octal_psram_example.c regions.c
  group devices
    ../../../../../../devices/: am_devices_mspi_psram_aps12808l.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
