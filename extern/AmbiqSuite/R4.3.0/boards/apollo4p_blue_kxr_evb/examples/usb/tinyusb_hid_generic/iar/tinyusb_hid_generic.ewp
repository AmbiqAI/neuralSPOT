# IAR project tinyusb_hid_generic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; apollo4p_blue_kxr_evb; CFG_TUSB_DEBUG=2; CFG_TUSB_MCU=OPT_MCU_APOLLO4; AM_PART_APOLLO4P
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..; ..\src; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\tinyusb\src\class\hid; ..\..\..\..\..\..\third_party\tinyusb\src; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\third_party\tinyusb\src\common; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\tinyusb\src\osal
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_hid_generic.bin
  ILINK.IlinkOutputFile: tinyusb_hid_generic.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; apollo4p_blue_kxr_evb; CFG_TUSB_DEBUG=2; CFG_TUSB_MCU=OPT_MCU_APOLLO4; AM_PART_APOLLO4P
  group (top)
    ../../../../../../third_party/tinyusb/src/device/: usbd.c usbd_control.c
    ../src/: am_resources.c apollo4_board.c tinyusb_hid_generic.c usb_descriptors.c
    ../../../../../../third_party/tinyusb/src/common/: tusb_fifo.c
    ../../../../../../third_party/tinyusb/src/portable/ambiq/apollo4/: dcd_apollo4.c
    ../../../../../../third_party/tinyusb/src/: tusb.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/tinyusb/src/class/hid/: hid_device.c
    ./: startup_iar.c
