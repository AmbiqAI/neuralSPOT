# Keil uVision project tinyusb_cdc_msc_freertos.uvprojx, settings and files
target tinyusb_cdc_msc_freertos (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: tinyusb_cdc_msc_freertos
  AfterMake: fromelf --bin --output bin\tinyusb_cdc_msc_freertos.bin bin\tinyusb_cdc_msc_freertos.axf
  AfterMake: fromelf -cedrst --output bin\tinyusb_cdc_msc_freertos.txt bin\tinyusb_cdc_msc_freertos.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO4P CFG_TUSB_MCU=OPT_MCU_APOLLO4 AM_FREERTOS apollo4p_blue_kbr_evb CFG_TUSB_DEBUG=2 BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED AM_PACKAGE_BGA keil
  c include: ../../../../../..;../../../../../../third_party/tinyusb/source/src/osal;../../../../../../CMSIS/ARM/Include;../../../../bsp;../../../../../../mcu/apollo4p;../../../../../../mcu/apollo4p/hal;../../../../../../third_party/FreeRTOSv10.5.1/Source/include;../../../../../../third_party/tinyusb/source/src/common;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil/AMapollo4;../../../../../../third_party/tinyusb/source/src/class/cdc;../../../../../../third_party/tinyusb/source/src/class/msc;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/tinyusb/source/src;../src;../../../../../../utils;../../../../../../devices
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib
  group FreeRTOSv10.5.1_AMapollo4
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil/AMapollo4/: port.c
  group tinyusb_src
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
  group src
    ../src/: am_resources.c apollo4_board.c freertos_hook.c msc_disk.c rtos.c tinyusb_cdc_msc_freertos.c usb_descriptors.c
  group tinyusb_apollo4
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
  group tinyusb_device
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
  group tinyusb_common
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
  group tinyusb_cdc
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
  group tinyusb_msc
    ../../../../../../third_party/tinyusb/source/src/class/msc/: msc_device.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
