# IAR project pdm_rtt_stream.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO4B; SEGGER_RTT_SECTION="SHARED_RW"; __FPU_PRESENT; AM_UTIL_FAULTISR_PRINT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\devices; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\SEGGER\SEGGER_RTT_V680a\RTT; ..\..\..\..\..\..\mcu\apollo4b; ..\src; ..\..\..\..\..\..\utils; ..\..\..\..\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: pdm_rtt_stream.bin
  ILINK.IlinkOutputFile: pdm_rtt_stream.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO4B; SEGGER_RTT_SECTION="SHARED_RW"; __FPU_PRESENT; AM_UTIL_FAULTISR_PRINT
  group (top)
    ../src/: am_resources.c pdm_rtt_stream.c
    ../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
