# Keil uVision project apollo4_sec_bl.uvprojx, settings and files
target apollo4_sec_bl (ARM-ADS)
  device: AMAP42KL-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.0
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: apollo4_sec_bl
  AfterMake: fromelf --bin --output bin\apollo4_sec_bl.bin bin\apollo4_sec_bl.axf
  AfterMake: fromelf -cedrst --output bin\apollo4_sec_bl.txt bin\apollo4_sec_bl.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_HAL_FLASH_PAGE_SIZE=8192 AM_PACKAGE_BGA AM_PART_APOLLO4L keil6
  c include: ../../../../../../utils;../../../../../../devices;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../..;../src;../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo4l;../../../../bsp
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4l/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c apollo4_secblProc.c apollo4_sec_bl.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4l/hal/mcu/keil6/bin/: libam_hal.lib
