# IAR project ble_freertos_eatt_watch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; WSF_TRACE_ENABLED; AM_BLE_EATT; SEC_ECC_CFG=SEC_ECC_CFG_HCI; AM_PART_APOLLO4P; AM_FREERTOS; AM_PACKAGE_BGA; AM_DEBUG_PRINTF
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\anpc; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\include; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\services; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\bas; ..\..\..\..\..\..\third_party\cordio\ble-profiles\include\app; ..\..\..\..\..\..\third_party\cordio\ble-host\include; ..\src; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\dis; ..\..\..\..\..\..\third_party\cordio\ble-host\sources\stack\dm; ..\..\..\..\..\..\third_party\cordio\ble-host\sources\stack\hci; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\hid; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\apps\watch; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\wdxs; ..\..\..\..\..\..\third_party\uecc; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\paspc; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\include; ..\..\..\..\..\..\third_party\cordio\ble-host\sources\stack\smp; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\uribeacon; ..\..\..\..\..\..\third_party\cordio\ble-host\sources\stack\cfg; ..\..\..\..\..\..\third_party\cordio\ble-host\sources\hci\ambiq; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\cordio\ble-host\sources\stack\l2c; ..\..\..\..\..\..\third_party\cordio\wsf\sources\util; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\apps; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\gap; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\gatt; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\apps\app; ..\..\..\..\..\..\third_party\cordio\ble-host\sources\hci\ambiq\cooper; ..\..\..\..\..\..; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\third_party\cordio\wsf\sources\port\freertos; ..\..\..\..\..\..\third_party\cordio\ble-host\sources\sec\common; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\cordio\wsf\sources; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\third_party\cordio\wsf\include; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\tipc; ..\..\..\..\..\..\mcu\apollo4p\hal\mcu; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\portable\IAR\AMapollo4; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\cordio\ble-host\sources\stack\att; ..\..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\hrpc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_freertos_eatt_watch.bin
  ILINK.IlinkOutputFile: ble_freertos_eatt_watch.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; WSF_TRACE_ENABLED; AM_BLE_EATT; SEC_ECC_CFG=SEC_ECC_CFG_HCI; AM_PART_APOLLO4P; AM_FREERTOS; AM_PACKAGE_BGA; AM_DEBUG_PRINTF
  group (top)
    ../../../../../../third_party/cordio/ble-profiles/sources/apps/app/common/: app_db.c app_hw.c app_ui.c ui_console.c ui_lcd.c ui_main.c ui_platform.c ui_timer.c
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/anpc/: anpc_main.c
    ../../../../../../third_party/cordio/ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
    ../../../../../../third_party/cordio/wsf/sources/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../../../../../third_party/cordio/ble-host/sources/stack/att/: attc_disc.c attc_eatt.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_eatt.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c att_eatt.c att_main.c att_uuid.c
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/gap/: gap_main.c
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/bas/: bas_main.c
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/gatt/: gatt_main.c
    ../../../../../../third_party/cordio/ble-host/sources/hci/ambiq/cooper/: hci_dbg_trc.c hci_drv_cooper.c hci_vs_cooper.c
    ../src/: am_resources.c ble_freertos_eatt_watch.c radio_task.c rtos.c
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/fmpl/: fmpl_main.c
    ../../../../../../third_party/cordio/wsf/sources/port/freertos/: wsf_assert.c wsf_buf.c wsf_efs.c wsf_math.c wsf_msg.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/dis/: dis_main.c
    ../../../../../../third_party/cordio/ble-host/sources/sec/common/: sec_aes.c sec_aes_rev.c sec_ccm_hci.c sec_cmac_hci.c sec_ecc_debug.c sec_ecc_hci.c sec_main.c
    ../../../../../../third_party/cordio/ble-host/sources/stack/dm/: dm_adv.c dm_adv_ae.c dm_adv_leg.c dm_bis_master.c dm_bis_slave.c dm_cis.c dm_cis_master.c dm_cis_slave.c dm_cis_sm.c dm_conn.c dm_conn_cte.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_iso.c dm_main.c dm_past.c dm_phy.c dm_priv.c dm_scan.c dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
    ../../../../../../third_party/cordio/ble-host/sources/stack/hci/: hci_main.c
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/hid/: hid_main.c
    ../../../../../../third_party/cordio/ble-profiles/sources/apps/watch/: watch_main.c
    ../../../../../../third_party/cordio/ble-host/sources/sec/uecc/: sec_ecc.c
    ../../../../../../third_party/uecc/: uECC.c uECC_ll.c
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/tipc/: tipc_main.c
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/paspc/: paspc_main.c
    ../../../../../../third_party/cordio/ble-host/sources/stack/smp/: smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c smp_act.c smp_db.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../../../../../../third_party/cordio/ble-host/sources/stack/cfg/: cfg_stack.c
    ../../../../../../third_party/cordio/ble-host/sources/hci/ambiq/: hci_cmd.c hci_cmd_ae.c hci_cmd_bis.c hci_cmd_cis.c hci_cmd_cte.c hci_cmd_iso.c hci_cmd_past.c hci_cmd_phy.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs_ae.c
    ../../../../../../third_party/cordio/ble-profiles/sources/apps/hidapp/: hidapp_main.c
    ../../../../../../third_party/cordio/ble-profiles/sources/profiles/hrpc/: hrpc_main.c
    ../../../../../../devices/: am_devices_button.c am_devices_cooper.c am_devices_led.c
    ../../../../../../utils/: am_util_ble_cooper.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../third_party/cordio/ble-profiles/sources/apps/app/: app_disc.c app_main.c app_master.c app_master_ae.c app_master_leg.c app_server.c app_slave.c app_slave_ae.c app_slave_leg.c app_terminal.c
    ../../../../../../third_party/cordio/ble-profiles/sources/services/: svc_alert.c svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_cte.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_time.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ./: startup_iar.c
