<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\uart_stream_echo_rxDma.ewp</path>
  </project>
  <batchBuild/>
</workspace>



