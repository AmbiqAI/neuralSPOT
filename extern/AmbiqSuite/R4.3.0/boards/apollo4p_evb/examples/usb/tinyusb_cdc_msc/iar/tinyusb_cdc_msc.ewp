# IAR project tinyusb_cdc_msc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; CFG_TUSB_DEBUG=2; CFG_TUSB_MCU=OPT_MCU_APOLLO4; AM_PART_APOLLO4P; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED; apollo4p_evb
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\tinyusb\src\common; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\tinyusb\src; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\..\..\..\..\..\third_party\tinyusb\src\class\msc; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\tinyusb\src\osal; ..\..\..\..\..\..\third_party\tinyusb\src\class\cdc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc_msc.bin
  ILINK.IlinkOutputFile: tinyusb_cdc_msc.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; CFG_TUSB_DEBUG=2; CFG_TUSB_MCU=OPT_MCU_APOLLO4; AM_PART_APOLLO4P; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED; apollo4p_evb
  group (top)
    ../../../../../../third_party/tinyusb/src/portable/ambiq/apollo4/: dcd_apollo4.c
    ../../../../../../third_party/tinyusb/src/: tusb.c
    ../src/: am_resources.c apollo4_board.c msc_disk.c tinyusb_cdc_msc.c usb_descriptors.c
    ../../../../../../third_party/tinyusb/src/device/: usbd.c usbd_control.c
    ../../../../../../third_party/tinyusb/src/common/: tusb_fifo.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/tinyusb/src/class/msc/: msc_device.c
    ../../../../../../third_party/tinyusb/src/class/cdc/: cdc_device.c
    ./: startup_iar.c
