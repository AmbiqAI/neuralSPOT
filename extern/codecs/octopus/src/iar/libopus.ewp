# IAR project libopus.ewp, settings and files
configuration lib (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KCR AmbiqMicro AMA3B1KK-KCR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: HAVE_CONFIG_H
  ICCARM.CCIncludePath2: ..\include; ..\celt; ..\iar
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration tst (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: libopus_tst.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: README
    ../win32/tst_octopus/: tst_octopus.c
  group src
    ../celt/: bands.c celt.c celt_encoder.c celt_lpc.c cwrs.c entcode.c entdec.c entdec.h entenc.c kiss_fft.c laplace.c mathops.c mdct.c modes.c pitch.c quant_bands.c rate.c vq.c
    ../src/: mlp.c mlp_data.c oct_opus_encoder.c opus.c repacketizer.c
  group wrapper
    ../../../lib/: ae_api.c
    ./: ae_api.h
