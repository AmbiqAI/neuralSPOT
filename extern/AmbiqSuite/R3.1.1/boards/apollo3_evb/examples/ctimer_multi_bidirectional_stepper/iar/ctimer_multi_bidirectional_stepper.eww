<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\ctimer_multi_bidirectional_stepper.ewp</path>
  </project>
  <batchBuild/>
</workspace>



