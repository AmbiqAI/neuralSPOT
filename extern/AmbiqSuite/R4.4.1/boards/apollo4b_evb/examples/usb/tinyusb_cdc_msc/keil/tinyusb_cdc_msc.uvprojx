# Keil uVision project tinyusb_cdc_msc.uvprojx, settings and files
target tinyusb_cdc_msc (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: tinyusb_cdc_msc
  AfterMake: fromelf --bin --output bin\tinyusb_cdc_msc.bin bin\tinyusb_cdc_msc.axf
  AfterMake: fromelf -cedrst --output bin\tinyusb_cdc_msc.txt bin\tinyusb_cdc_msc.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA apollo4b_evb CFG_TUSB_MCU=OPT_MCU_APOLLO4 BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED AM_PART_APOLLO4B CFG_TUSB_DEBUG=2 keil
  c include: ../../../../bsp;../src;../../../../../../third_party/tinyusb/source/src/class/msc;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../CMSIS/ARM/Include;../../../../../..;../../../../../../third_party/tinyusb/source/src/osal;../../../../../../third_party/tinyusb/source/src/common;../../../../../../mcu/apollo4b;../../../../../../third_party/tinyusb/source/src;../../../../../../third_party/tinyusb/source/src/class/cdc;../../../../../../mcu/apollo4b/hal;../../../../../../devices;../../../../../../utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib
  group src
    ../src/: am_resources.c apollo4_board.c msc_disk.c tinyusb_cdc_msc.c usb_descriptors.c
  group tinyusb_src
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
  group tinyusb_device
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
  group tinyusb_apollo4
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
  group tinyusb_common
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
  group tinyusb_msc
    ../../../../../../third_party/tinyusb/source/src/class/msc/: msc_device.c
  group tinyusb_cdc
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
