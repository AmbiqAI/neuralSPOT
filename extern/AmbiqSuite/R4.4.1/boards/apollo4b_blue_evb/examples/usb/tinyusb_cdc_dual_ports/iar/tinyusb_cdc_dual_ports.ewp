# IAR project tinyusb_cdc_dual_ports.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED; apollo4b_blue_evb; AM_PACKAGE_BGA; CFG_TUSB_MCU=OPT_MCU_APOLLO4; AM_PART_APOLLO4B; CFG_TUSB_DEBUG=2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\tinyusb\source\src\class\cdc; ..\..\..\..\..\..\third_party\tinyusb\source\src\osal; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\tinyusb\source\src; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\tinyusb\source\src\common; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\utils; ..\src; ..\..\..\..\..\..\mcu\apollo4b\hal
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc_dual_ports.bin
  ILINK.IlinkOutputFile: tinyusb_cdc_dual_ports.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED; apollo4b_blue_evb; AM_PACKAGE_BGA; CFG_TUSB_MCU=OPT_MCU_APOLLO4; AM_PART_APOLLO4B; CFG_TUSB_DEBUG=2
  group (top)
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
    ../src/: am_resources.c apollo4_board.c tinyusb_cdc_dual_ports.c usb_descriptors.c
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
    ./: startup_iar.c
