# IAR project sdio_wifi_interface_raw_read_write.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP330MPA-CBR AmbiqMicro AP330MPA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_DEBUG_PRINTF; AM_PART_APOLLO330P
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\utils; ..\src; ..\..\..\..\..\..\mcu\apollo330P; ..\..\..\..\..\..\mcu\apollo330P\hal; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..; ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sdio_wifi_interface_raw_read_write.bin
  ILINK.IlinkOutputFile: sdio_wifi_interface_raw_read_write.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo330P\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_DEBUG_PRINTF; AM_PART_APOLLO330P
  group (top)
    ../src/: am_resources.c sdio_wifi_interface_raw_read_write.c
    ../../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
    ../../../../../../devices/: am_devices_sdio_rs9116.c
    ./: startup_iar.c
