# Keil uVision project iom_fram.uvprojx, settings and files
target iom_fram (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: iom_fram
  AfterMake: fromelf --bin --output bin\iom_fram.bin bin\iom_fram.axf
  AfterMake: fromelf -cedrst --output bin\iom_fram.txt bin\iom_fram.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3 keil6
  c include: ../../../../../CMSIS/AmbiqMicro/Include;../../../../../utils;../../../../../devices;../src;../../../../../CMSIS/ARM/Include;../../../../../mcu/apollo3;../../../bsp;../../../../..
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\iom_fram.sct
  link misc: ../../../../../mcu/apollo3/hal/keil6/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data) --undefined=__scatterload_copy
  group src
    ../src/: iom_fram.c
  group devices
    ../../../../../devices/: am_devices_mb85rc256v.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil6/bin/: libam_hal.lib
