# Keil uVision project i2s_loopback.uvprojx, settings and files
target i2s_loopback (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: i2s_loopback
  AfterMake: fromelf --bin --output bin\i2s_loopback.bin bin\i2s_loopback.axf
  AfterMake: fromelf -cedrst --output bin\i2s_loopback.txt bin\i2s_loopback.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO4P __FPU_PRESENT UNITY_INCLUDE_CONFIG_H AM_UTIL_FAULTISR_PRINT keil
  c include: ../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../devices;../../../../../../mcu/apollo4p;../../../../bsp;../src;../../../../../../utils;../../../../../../CMSIS/ARM/Include;../../../../../..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c i2s_loopback.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../../../CMSIS/ARM/Lib/ARM/: arm_cortexM4lf_math.lib
