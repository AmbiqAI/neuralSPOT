<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\coremark_best_cm_per_mJ.ewp</path>
  </project>
  <batchBuild/>
</workspace>



