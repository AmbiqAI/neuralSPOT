# Keil uVision project apollo3_sec_bl.uvprojx, settings and files
target apollo3_sec_bl (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: apollo3_sec_bl
  AfterMake: fromelf --bin --output bin\apollo3_sec_bl.bin bin\apollo3_sec_bl.axf
  AfterMake: fromelf -cedrst --output bin\apollo3_sec_bl.txt bin\apollo3_sec_bl.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3 keil6
  c include: ../../../../../CMSIS/AmbiqMicro/Include;../../../bsp;../../../../../utils;../../../../..;../../../../../CMSIS/ARM/Include;../src;../../../../../devices;../../../../../mcu/apollo3
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\apollo3_sec_bl.sct
  link misc: ../../../../../mcu/apollo3/hal/keil6/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data) --undefined=__scatterload_copy
  group src
    ../src/: apollo3_secbl.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../mcu/apollo3/hal/keil6/bin/: libam_hal.lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
