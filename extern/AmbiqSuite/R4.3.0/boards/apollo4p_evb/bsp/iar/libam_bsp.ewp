# IAR project libam_bsp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; DISP_TYPE=RM67162_DSI; NUM_LANES=1; DISP_CFG; B_USE_DPHYPLL=true; DSI_FREQ=AM_HAL_DSI_FREQ_TRIM_X12; AM_PART_APOLLO4P; DBI_WIDTH=AM_HAL_DSI_DBI_WIDTH_8
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\utils; ..\..\..\..\mcu\apollo4p; ..\..\..\..\devices; ..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: libam_bsp.bin
  ILINK.IlinkOutputFile: libam_bsp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  group (top)
    ../: am_bsp.c am_bsp_pins.c
