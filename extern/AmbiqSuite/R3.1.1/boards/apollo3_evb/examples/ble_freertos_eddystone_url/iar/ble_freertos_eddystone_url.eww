<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\ble_freertos_eddystone_url.ewp</path>
  </project>
  <batchBuild/>
</workspace>



