# Keil uVision project sdio_wifi_interface_raw_read_write.uvprojx, settings and files
target sdio_wifi_interface_raw_read_write (6160000::V6.16::ARMCLANG)
  device: AP330MPA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.4
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: sdio_wifi_interface_raw_read_write
  AfterMake: fromelf --bin --output bin\sdio_wifi_interface_raw_read_write.bin bin\sdio_wifi_interface_raw_read_write.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AM_PACKAGE_BGA AM_DEBUG_PRINTF AM_PART_APOLLO330P keil6
  c include: ../../../../../../utils;../src;../../../../../../mcu/apollo330P;../../../../../../mcu/apollo330P/hal;../../../../../../CMSIS/ARM/Include;../../../../../..;../../../../bsp;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../devices
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo330P/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c sdio_wifi_interface_raw_read_write.c
  group utils
    ../../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_sdio_rs9116.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo330P/hal/mcu/keil6/bin/: libam_hal.lib
software components: Device:Startup 1.1.0
