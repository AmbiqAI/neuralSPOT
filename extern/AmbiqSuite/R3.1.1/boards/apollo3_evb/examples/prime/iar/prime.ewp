# IAR project prime.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PRINTF_BUFSIZE=256; AM_PART_APOLLO3; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\bsp; ..\..\..\..\..\utils; ..\..\..\..\..; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\src; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\devices
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: prime.bin
  ILINK.IlinkOutputFile: prime.out
  ILINK.IlinkIcfFile: prime.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PRINTF_BUFSIZE=256; AM_PART_APOLLO3; AM_PACKAGE_BGA
  group (top)
    ../../../../../third_party/prime_mpi/src/: prime_mpi.c
    ../src/: prime.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../devices/: am_devices_led.c
    ./: startup_iar.c
