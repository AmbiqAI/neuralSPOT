# Keil uVision project tinyusb_cdc.uvprojx, settings and files
target tinyusb_cdc (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: tinyusb_cdc
  AfterMake: fromelf --bin --output bin\tinyusb_cdc.bin bin\tinyusb_cdc.axf
  AfterMake: fromelf -cedrst --output bin\tinyusb_cdc.txt bin\tinyusb_cdc.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_TUSB_DEBUG=2 AM_PART_APOLLO4P BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED CFG_TUSB_MCU=OPT_MCU_APOLLO4 AM_PACKAGE_BGA apollo4p_blue_kxr_evb keil
  c include: ../../../../../../mcu/apollo4p/hal;../../../../../../utils;../../../../../../third_party/tinyusb/source/src/osal;../src;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/tinyusb/source/src/class/cdc;../../../../bsp;../../../../../../mcu/apollo4p;../../../../../../third_party/tinyusb/source/src/common;../../../../../../third_party/tinyusb/source/src;../../../../../../devices;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib
  group tinyusb_device
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
  group tinyusb_common
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
  group src
    ../src/: am_resources.c apollo4_board.c tinyusb_cdc.c usb_descriptors.c
  group tinyusb_src
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
  group tinyusb_apollo4
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
  group tinyusb_cdc
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
