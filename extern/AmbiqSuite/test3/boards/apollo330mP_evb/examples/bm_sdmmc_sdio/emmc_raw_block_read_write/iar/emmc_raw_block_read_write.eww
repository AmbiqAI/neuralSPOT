<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\emmc_raw_block_read_write.ewp</path>
  </project>
  <batchBuild/>
</workspace>



