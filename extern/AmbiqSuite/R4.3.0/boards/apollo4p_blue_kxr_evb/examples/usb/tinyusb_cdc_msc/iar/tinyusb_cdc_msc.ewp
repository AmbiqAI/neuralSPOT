# IAR project tinyusb_cdc_msc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; apollo4p_blue_kxr_evb; CFG_TUSB_MCU=OPT_MCU_APOLLO4; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED; CFG_TUSB_DEBUG=2; AM_PART_APOLLO4P; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\tinyusb\src; ..\..\..\..\..\..\third_party\tinyusb\src\osal; ..\src; ..\..\..\..\..\..\third_party\tinyusb\src\class\cdc; ..\..\..\..\..\..\third_party\tinyusb\src\class\msc; ..\..\..\..\..\..; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\third_party\tinyusb\src\common; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\utils
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc_msc.bin
  ILINK.IlinkOutputFile: tinyusb_cdc_msc.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; apollo4p_blue_kxr_evb; CFG_TUSB_MCU=OPT_MCU_APOLLO4; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED; CFG_TUSB_DEBUG=2; AM_PART_APOLLO4P; AM_PACKAGE_BGA
  group (top)
    ../../../../../../third_party/tinyusb/src/portable/ambiq/apollo4/: dcd_apollo4.c
    ../../../../../../third_party/tinyusb/src/: tusb.c
    ../../../../../../third_party/tinyusb/src/device/: usbd.c usbd_control.c
    ../src/: am_resources.c apollo4_board.c msc_disk.c tinyusb_cdc_msc.c usb_descriptors.c
    ../../../../../../third_party/tinyusb/src/common/: tusb_fifo.c
    ../../../../../../third_party/tinyusb/src/class/cdc/: cdc_device.c
    ../../../../../../third_party/tinyusb/src/class/msc/: msc_device.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ./: startup_iar.c
