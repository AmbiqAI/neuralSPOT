<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\ble_freertos_fit_lp.ewp</path>
  </project>
  <batchBuild/>
</workspace>



