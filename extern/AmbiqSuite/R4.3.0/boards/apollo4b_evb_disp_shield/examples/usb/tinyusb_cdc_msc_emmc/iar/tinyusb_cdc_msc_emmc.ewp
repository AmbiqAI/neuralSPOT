# IAR project tinyusb_cdc_msc_emmc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; apollo4b_evb_disp_shield; CFG_TUSB_MCU=OPT_MCU_APOLLO4; AM_PART_APOLLO4B; AM_PACKAGE_BGA; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\tinyusb\src\common; ..\..\..\..\..\..\utils; ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\third_party\tinyusb\src\class\msc; ..\..\..\..\..\..\third_party\tinyusb\src\osal; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\third_party\tinyusb\src\class\cdc; ..\..\..\..\..\..\third_party\tinyusb\src; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo4b
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc_msc_emmc.bin
  ILINK.IlinkOutputFile: tinyusb_cdc_msc_emmc.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; apollo4b_evb_disp_shield; CFG_TUSB_MCU=OPT_MCU_APOLLO4; AM_PART_APOLLO4B; AM_PACKAGE_BGA; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED
  group (top)
    ../src/: am_resources.c apollo4_board.c msc_emmc_disk.c tinyusb_cdc_msc_emmc.c usb_descriptors.c
    ../../../../../../third_party/tinyusb/src/common/: tusb_fifo.c
    ../../../../../../third_party/tinyusb/src/: tusb.c
    ../../../../../../third_party/tinyusb/src/device/: usbd.c usbd_control.c
    ../../../../../../third_party/tinyusb/src/portable/ambiq/apollo4/: dcd_apollo4.c
    ../../../../../../third_party/tinyusb/src/class/cdc/: cdc_device.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/tinyusb/src/class/msc/: msc_device.c
    ./: startup_iar.c
