# Keil uVision project rtc_print.uvprojx, settings and files
target rtc_print (ARM-ADS)
  device: AMAP42KL-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.0
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: rtc_print
  AfterMake: fromelf --bin --output bin\rtc_print.bin bin\rtc_print.axf
  AfterMake: fromelf -cedrst --output bin\rtc_print.txt bin\rtc_print.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO4L AM_PACKAGE_BGA keil
  c misc: --reduce_paths
  c include: ../../../../../../CMSIS/AmbiqMicro/Include;../../../../../..;../../../../../../utils;../src;../../../../../../devices;../../../../../../mcu/apollo4l;../../../../bsp;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4l/hal/mcu/keil/bin/libam_hal.lib
  group src
    ../src/: am_resources.c rtc_print.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_string.c am_util_time.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4l/hal/mcu/keil/bin/: libam_hal.lib
