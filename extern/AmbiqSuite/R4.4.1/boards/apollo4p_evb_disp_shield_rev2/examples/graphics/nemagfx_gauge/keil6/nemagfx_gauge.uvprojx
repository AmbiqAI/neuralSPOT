# Keil uVision project nemagfx_gauge.uvprojx, settings and files
target nemagfx_gauge (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_gauge
  AfterMake: fromelf --bin --output bin\nemagfx_gauge.bin bin\nemagfx_gauge.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_gauge.txt bin\nemagfx_gauge.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib NEMA_PLATFORM=apollo4p_nemagfx CALCULATE_FPS AM_PART_APOLLO4P ENABLE_TE AM_FREERTOS USE_NEMAGUI_LIB USE_TSI_MALLOC keil6
  c include: ../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../src/generated/NemaGUI/include/gitems;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo4;../src/generated/assets/fonts;../src/generated/assets/images;../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx;../src;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../utils;../../../../../../mcu/apollo4p/hal/mcu;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../mcu/apollo4p/hal;../../../../../../mcu/apollo4p;../src/generated;../../../../../../third_party/FreeRTOSv10.5.1/Source/include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../bsp;../../../../../../devices;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../src/generated/NemaGUI/include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group FreeRTOSv10.5.1_AMapollo4
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo4/: port.c
  group src
    ../src/: am_resources.c gui_task.c nemagfx_gauge.c nemagui_porting.c rtos.c
  group ThinkSi_apollo4p_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group generated
    ../src/generated/: custom_callbacks.c event_list.c fonts.c framebuffers.c gui_tree.c images.c main.c screen_groups.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group devices
    ../../../../../../devices/: am_devices_display_generic.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/keil6/bin/: lib_nema_apollo4p_nemagfx.lib
    ../../../../../../third_party/NemaGUI/config/apollo4p/keil/bin/: NemaGUI.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
