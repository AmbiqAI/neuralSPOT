# Keil uVision project nemadc_spi_configurations.uvprojx, settings and files
target nemadc_spi_configurations (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemadc_spi_configurations
  AfterMake: fromelf --bin --output bin\nemadc_spi_configurations.bin bin\nemadc_spi_configurations.axf
  AfterMake: fromelf -cedrst --output bin\nemadc_spi_configurations.txt bin\nemadc_spi_configurations.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO4P NEMA_PLATFORM=apollo4p_nemagfx AM_PACKAGE_BGA LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib BAREMETAL NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK keil6
  c include: ../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../..;../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../mcu/apollo4p;../../../../../../mcu/apollo4p/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../bsp;../../../../../../CMSIS/AmbiqMicro/Include;../src;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../utils;../../../../../../devices;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group ThinkSi_apollo4p_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group src
    ../src/: am_resources.c nemadc_spi_configurations.c
  group devices
    ../../../../../../devices/: am_devices_dc_xspi_raydium.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/keil6/bin/: lib_nema_apollo4p_nemagfx.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
