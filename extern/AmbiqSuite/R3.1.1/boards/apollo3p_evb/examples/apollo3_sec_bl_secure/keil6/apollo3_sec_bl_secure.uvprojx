# Keil uVision project apollo3_sec_bl_secure.uvprojx, settings and files
target apollo3_sec_bl_secure (ARM-ADS)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: apollo3_sec_bl_secure
  AfterMake: fromelf --bin --output bin\apollo3_sec_bl_secure.bin bin\apollo3_sec_bl_secure.axf
  AfterMake: fromelf -cedrst --output bin\apollo3_sec_bl_secure.txt bin\apollo3_sec_bl_secure.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO3P MBEDTLS_CONFIG_FILE=\"mbedtls_config.h\" AM_PACKAGE_BGA keil6
  c include: ../../../bsp;../../../../..;../../../../../devices;../../../../../CMSIS/ARM/Include;../../../../../mcu/apollo3p;../src;../../../../../third_party/mbedtls-2.4.2/include;../../../../../utils;../../../../../CMSIS/AmbiqMicro/Include
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil6/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data) --undefined=__scatterload_copy
  group src
    ../src/: apollo3_secbl.c apollo3_secbl_flash.c apollo3_secbl_image.c apollo3_secbl_info0.c apollo3_secbl_mspi_flash.c apollo3_secbl_secure.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group mbedtls-2.4.2_library
    ../../../../../third_party/mbedtls-2.4.2/library/: aes.c md.c md_wrap.c memory_buffer_alloc.c platform.c sha256.c
  group devices
    ../../../../../devices/: am_devices_mspi_atxp032.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3p/hal/keil6/bin/: libam_hal.lib
