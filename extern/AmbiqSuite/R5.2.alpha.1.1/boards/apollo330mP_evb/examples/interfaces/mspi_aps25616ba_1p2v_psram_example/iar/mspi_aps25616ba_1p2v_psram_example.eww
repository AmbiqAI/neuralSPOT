<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\mspi_aps25616ba_1p2v_psram_example.ewp</path>
  </project>
  <batchBuild/>
</workspace>



