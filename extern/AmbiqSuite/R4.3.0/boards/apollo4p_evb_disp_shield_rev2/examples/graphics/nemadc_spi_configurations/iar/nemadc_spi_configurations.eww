<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\nemadc_spi_configurations.ewp</path>
  </project>
  <batchBuild/>
</workspace>



