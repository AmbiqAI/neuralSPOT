# Keil uVision project uart_ble_bridge.uvprojx, settings and files
target uart_ble_bridge (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: uart_ble_bridge
  AfterMake: fromelf --bin --output bin\uart_ble_bridge.bin bin\uart_ble_bridge.axf
  AfterMake: fromelf -cedrst --output bin\uart_ble_bridge.txt bin\uart_ble_bridge.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO4B BLE_BRIDGE_SINGLE_MODE AM_PACKAGE_BGA keil
  c include: ../../../../../../utils;../../../../bsp;../../../../../..;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/cordio/ble-host/sources/hci/ambiq/cooper;../../../../../../mcu/apollo4b/hal;../../../../../../third_party/cordio/wsf/include;../src;../../../../../../third_party/cordio/wsf/sources/port/freertos;../../../../../../devices;../../../../../../mcu/apollo4b/hal/mcu;../../../../../../ambiq_ble/apps/dtm_module;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4b
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c uart_ble_bridge.c
  group utils
    ../../../../../../utils/: am_util_ble_cooper.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group dtm_module
    ../../../../../../ambiq_ble/apps/dtm_module/: dtm_main.c
  group devices
    ../../../../../../devices/: am_devices_cooper.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
