<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\mspi_ddr_psram_loader.ewp</path>
  </project>
  <batchBuild/>
</workspace>



