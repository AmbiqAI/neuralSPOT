# Keil uVision project mspi_octal_example.uvprojx, settings and files
target mspi_octal_example (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: mspi_octal_example
  AfterMake: fromelf --bin --output bin\mspi_octal_example.bin bin\mspi_octal_example.axf
  AfterMake: fromelf -cedrst --output bin\mspi_octal_example.txt bin\mspi_octal_example.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_UTIL_FAULTISR_PRINT AM_DEBUG_PRINTF AM_PACKAGE_BGA AM_PART_APOLLO4P keil
  c include: ../../../../../../devices;../../../../../..;../src;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4p;../../../../../../CMSIS/ARM/Include;../../../../bsp;../../../../../../utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c mspi_octal_example.c
  group devices
    ../../../../../../devices/: am_devices_mspi_atxp032.c am_devices_mspi_is25wx064.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
