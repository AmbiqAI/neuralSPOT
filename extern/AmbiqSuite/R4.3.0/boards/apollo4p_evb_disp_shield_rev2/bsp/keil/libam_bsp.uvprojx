# Keil uVision project libam_bsp.uvprojx, settings and files
target libam_bsp (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x0001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: libam_bsp (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DSI_FREQ=AM_HAL_DSI_FREQ_TRIM_X20 DISP_CFG DISP_TYPE=RM69330_DSI NUM_LANES=1 AM_PART_APOLLO4P B_USE_DPHYPLL=false AM_PACKAGE_BGA DBI_WIDTH=AM_HAL_DSI_DBI_WIDTH_16 keil
  c include: ../../../../devices;../../../../CMSIS/ARM/Include;../../../../mcu/apollo4p;../../../../CMSIS/AmbiqMicro/Include;../../../../utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  group source_files
    ../: am_bsp.c am_bsp_pins.c
