<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\ble_freertos_power_cycle.ewp</path>
  </project>
  <batchBuild/>
</workspace>



