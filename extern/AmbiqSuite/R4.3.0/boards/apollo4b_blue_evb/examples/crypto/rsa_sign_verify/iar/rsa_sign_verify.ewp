# IAR project rsa_sign_verify.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_UTIL_FAULTISR_PRINT; AM_PACKAGE_BGA; CC_IOT; AM_PART_APOLLO4B
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\devices; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\crypto\host\include; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\crypto\shared\include\pal\no_os; ..\..\..\..\..\..\third_party\crypto\mbedtls\include; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\crypto\shared\include\pal; ..\..\..\..\..\..\mcu\apollo4b; ..\src; ..\..\..\..\..\..; ..\..\..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rsa_sign_verify.bin
  ILINK.IlinkOutputFile: rsa_sign_verify.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\third_party\crypto\host\lib\libcc_312.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedcrypto.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedtls.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libpal_no_os.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_UTIL_FAULTISR_PRINT; AM_PACKAGE_BGA; CC_IOT; AM_PART_APOLLO4B
  group (top)
    ../src/: am_resources.c rsa_sign_verify.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
