# Keil uVision project emmc_raw_block_read_write.uvprojx, settings and files
target emmc_raw_block_read_write (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: emmc_raw_block_read_write
  AfterMake: fromelf --bin --output bin\emmc_raw_block_read_write.bin bin\emmc_raw_block_read_write.axf
  AfterMake: fromelf -cedrst --output bin\emmc_raw_block_read_write.txt bin\emmc_raw_block_read_write.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_DEBUG_PRINTF AM_PART_APOLLO4P AM_PACKAGE_BGA keil
  c include: ../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo4p;../../../../../../mcu/apollo4p/hal;../../../../../..;../src;../../../../../../utils;../../../../bsp;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../devices
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c emmc_raw_block_read_write.c
  group utils
    ../../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
