# Keil uVision project freertos_sample.uvprojx, settings and files
target freertos_sample (6160000::V6.16::ARMCLANG)
  device: AP330MPA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.4
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: freertos_sample
  AfterMake: fromelf --bin --output bin\freertos_sample.bin bin\freertos_sample.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AM_UTIL_FAULTISR_PRINT AM_FREERTOS AM_PACKAGE_BGA AM_PART_APOLLO330P keil6
  c include: ../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo330P/hal/mcu;../../../../../../utils;../../../../../../third_party/FreeRTOSv10.5.1/Source/include;../src;../../../../../../mcu/apollo330P/hal;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo5;../../../../bsp;../../../../../../devices;../../../../../..;../../../../../../mcu/apollo330P;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo330P/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group FreeRTOSv10.5.1_AMapollo5
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo5/: port.c portasm.c port_stimer.c port_systick_stimer.c
  group src
    ../src/: am_resources.c freertos_sample.c hello_task.c print_task.c rtos.c timer_task.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo330P/hal/mcu/keil6/bin/: libam_hal.lib
software components: Device:Startup 1.1.0
