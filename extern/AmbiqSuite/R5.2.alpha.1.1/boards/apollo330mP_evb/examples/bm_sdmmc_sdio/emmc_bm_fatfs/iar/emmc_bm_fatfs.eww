<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\emmc_bm_fatfs.ewp</path>
  </project>
  <batchBuild/>
</workspace>



