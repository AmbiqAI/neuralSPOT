<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\sdio_wifi_interface_raw_read_write.ewp</path>
  </project>
  <batchBuild/>
</workspace>



