# Keil uVision project dsi_rw_command.uvprojx, settings and files
target dsi_rw_command (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: dsi_rw_command
  AfterMake: fromelf --bin --output bin\dsi_rw_command.bin bin\dsi_rw_command.axf
  AfterMake: fromelf -cedrst --output bin\dsi_rw_command.txt bin\dsi_rw_command.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK AM_PART_APOLLO4P BAREMETAL LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib NEMA_PLATFORM=apollo4p_nemagfx keil6
  c include: ../../../../../../CMSIS/ARM/Include;../../../../../../utils;../../../../bsp;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../src;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../..;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx;../../../../../../mcu/apollo4p;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4p/hal/mcu;../../../../../../devices;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../mcu/apollo4p/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c dsi_rw_command.c
  group ThinkSi_apollo4p_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group devices
    ../../../../../../devices/: am_devices_dc_dsi_raydium.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/keil6/bin/: lib_nema_apollo4p_nemagfx.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
