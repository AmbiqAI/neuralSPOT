# Keil uVision project ble_freertos_amota_dtm.uvprojx, settings and files
target ble_freertos_amota_dtm (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: ble_freertos_amota_dtm
  AfterMake: fromelf --bin --output bin\ble_freertos_amota_dtm.bin bin\ble_freertos_amota_dtm.axf
  AfterMake: fromelf -cedrst --output bin\ble_freertos_amota_dtm.txt bin\ble_freertos_amota_dtm.axf
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_MULTIBOOT_CONFIG_FILE=\"amota_profile_config.h\" AM_FREERTOS AM_DEBUG_PRINTF SEC_ECC_CFG=SEC_ECC_CFG_HCI AM_CUSTOM_BDADDR AM_PART_APOLLO3 WSF_TRACE_ENABLED AM_PACKAGE_BGA keil6
  c include: ../../../../../ambiq_ble/apps/amota;../src;../../../../../third_party/cordio/wsf/sources/util;../../../bsp;../../../../../third_party/cordio/ble-host/sources/stack/cfg;../../../../../CMSIS/AmbiqMicro/Include;../../../../../mcu/apollo3;../../../../../bootloader;../../../../../utils;../../../../../ambiq_ble/services;../../../../../third_party/cordio/ble-host/sources/hci/ambiq/apollo3;../../../../../third_party/cordio/ble-profiles/sources/profiles/include;../../../../../third_party/cordio/wsf/include;../../../../../third_party/cordio/ble-profiles/sources/apps/app;../../../../../third_party/cordio/ble-profiles/include/app;../../../../../third_party/cordio/ble-host/sources/stack/l2c;../../../../../third_party/cordio/ble-host/sources/stack/att;../../../../../CMSIS/ARM/Include;../../../../../third_party/cordio/ble-profiles/sources/apps;../../../../../third_party/cordio/ble-profiles/sources/services;../../../../../devices;../../../../../third_party/FreeRTOSv10.1.1/Source/include;../../../../../third_party/cordio/ble-host/sources/stack/dm;../../../../../third_party/cordio/ble-host/sources/hci/ambiq;../../../../../third_party/cordio/ble-profiles/sources/profiles/hid;../../../../../third_party/cordio/ble-profiles/sources/profiles/uribeacon;../../../../../third_party/cordio/ble-profiles/sources/profiles/gap;../../../../../third_party/cordio/ble-profiles/sources/profiles;../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil6/AMapollo2;../../../../../third_party/cordio/ble-profiles/sources/profiles/bas;../../../../../third_party/cordio/ble-host/sources/stack/smp;../../../../../third_party/cordio/ble-host/sources/stack/hci;../../../../../ambiq_ble/profiles/amota;../../../../../third_party/cordio/ble-profiles/sources/profiles/hrps;../../../../../third_party/uecc;../../../../../third_party/cordio/wsf/sources;../../../../../third_party/cordio/ble-profiles/sources/profiles/rscp;../../../../../third_party/cordio/ble-host/include;../../../../../third_party/cordio/wsf/sources/port/freertos;../../../../../third_party/cordio/ble-host/sources/sec/common;../../../../../third_party/cordio/ble-profiles/sources/profiles/gatt;../../../../..
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\ble_freertos_amota_dtm.sct
  link misc: ../../../../../mcu/apollo3/hal/keil6/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data) --undefined=__scatterload_copy
  group FreeRTOSv10.1.1_AMapollo2
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil6/AMapollo2/: port.c
  group amota
    ../../../../../ambiq_ble/apps/amota/: amota_main.c
  group cordio_bas
    ../../../../../third_party/cordio/ble-profiles/sources/profiles/bas/: bas_main.c
  group src
    ../src/: ble_freertos_amota.c radio_task.c rtos.c uart_ble_bridge_dtm.c
  group cordio_util
    ../../../../../third_party/cordio/wsf/sources/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
  group cordio_smp
    ../../../../../third_party/cordio/ble-host/sources/stack/smp/: smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c smp_act.c smp_db.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c
  group cordio_hci
    ../../../../../third_party/cordio/ble-host/sources/stack/hci/: hci_main.c
  group cordio_cfg
    ../../../../../third_party/cordio/ble-host/sources/stack/cfg/: cfg_stack.c
  group amota
    ../../../../../ambiq_ble/profiles/amota/: amotas_main.c
  group services
    ../../../../../ambiq_ble/services/: svc_amdtp.c svc_amotas.c svc_amvole.c svc_cust.c svc_throughput.c
  group cordio_apollo3
    ../../../../../third_party/cordio/ble-host/sources/hci/ambiq/apollo3/: hci_drv_apollo3.c hci_vs_apollo3.c
  group cordio_l2c
    ../../../../../third_party/cordio/ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
  group cordio_uecc
    ../../../../../third_party/cordio/ble-host/sources/sec/uecc/: sec_ecc.c
  group cordio_att
    ../../../../../third_party/cordio/ble-host/sources/stack/att/: attc_disc.c attc_eatt.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_eatt.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c att_eatt.c att_main.c att_uuid.c
  group cordio_common
    ../../../../../third_party/cordio/ble-profiles/sources/apps/app/common/: app_db.c app_hw.c app_ui.c ui_console.c ui_lcd.c ui_main.c ui_platform.c ui_timer.c
  group cordio_hrps
    ../../../../../third_party/cordio/ble-profiles/sources/profiles/hrps/: hrps_main.c
  group uecc_uecc
    ../../../../../third_party/uecc/: uECC.c uECC_ll.c
  group cordio_dm
    ../../../../../third_party/cordio/ble-host/sources/stack/dm/: dm_adv.c dm_adv_ae.c dm_adv_leg.c dm_bis_master.c dm_bis_slave.c dm_cis.c dm_cis_master.c dm_cis_slave.c dm_cis_sm.c dm_conn.c dm_conn_cte.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_iso.c dm_main.c dm_past.c dm_phy.c dm_priv.c dm_scan.c dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
  group cordio_rscp
    ../../../../../third_party/cordio/ble-profiles/sources/profiles/rscp/: rscps_main.c
  group cordio_ambiq
    ../../../../../third_party/cordio/ble-host/sources/hci/ambiq/: hci_cmd.c hci_cmd_ae.c hci_cmd_bis.c hci_cmd_cis.c hci_cmd_cte.c hci_cmd_iso.c hci_cmd_past.c hci_cmd_phy.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs_ae.c
  group cordio_common
    ../../../../../third_party/cordio/ble-host/sources/sec/common/: sec_aes.c sec_aes_rev.c sec_ccm_hci.c sec_cmac_hci.c sec_ecc_debug.c sec_ecc_hci.c sec_main.c
  group cordio_gatt
    ../../../../../third_party/cordio/ble-profiles/sources/profiles/gatt/: gatt_main.c
  group cordio_freertos
    ../../../../../third_party/cordio/wsf/sources/port/freertos/: wsf_assert.c wsf_buf.c wsf_efs.c wsf_math.c wsf_msg.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
  group cordio_hid
    ../../../../../third_party/cordio/ble-profiles/sources/profiles/hid/: hid_main.c
  group cordio_gap
    ../../../../../third_party/cordio/ble-profiles/sources/profiles/gap/: gap_main.c
  group cordio_hidapp
    ../../../../../third_party/cordio/ble-profiles/sources/apps/hidapp/: hidapp_main.c
  group bootloader
    ../../../../../bootloader/: am_bootloader.c am_multi_boot.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
  group cordio_services
    ../../../../../third_party/cordio/ble-profiles/sources/services/: svc_alert.c svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_cte.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_time.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
  group FreeRTOSv10.1.1_Source
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group cordio_app
    ../../../../../third_party/cordio/ble-profiles/sources/apps/app/: app_disc.c app_main.c app_master.c app_master_ae.c app_master_leg.c app_server.c app_slave.c app_slave_ae.c app_slave_leg.c app_terminal.c
  group devices
    ../../../../../devices/: am_devices_button.c am_devices_led.c
  group utils
    ../../../../../utils/: am_util_ble.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil6/bin/: libam_hal.lib
