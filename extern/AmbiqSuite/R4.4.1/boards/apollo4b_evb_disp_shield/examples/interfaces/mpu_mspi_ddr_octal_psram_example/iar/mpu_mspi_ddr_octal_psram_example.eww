<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\mpu_mspi_ddr_octal_psram_example.ewp</path>
  </project>
  <batchBuild/>
</workspace>



