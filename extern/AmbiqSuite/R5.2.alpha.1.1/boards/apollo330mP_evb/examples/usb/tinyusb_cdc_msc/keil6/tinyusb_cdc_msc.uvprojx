# Keil uVision project tinyusb_cdc_msc.uvprojx, settings and files
target tinyusb_cdc_msc (6160000::V6.16::ARMCLANG)
  device: AP330MPA-CBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.4
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: tinyusb_cdc_msc
  AfterMake: fromelf --bin --output bin\tinyusb_cdc_msc.bin bin\tinyusb_cdc_msc.axf
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AM_CFG_USB_EP4_OUT_DBUF_ENABLE AM_PART_APOLLO330P apollo330mP_evb CFG_TUSB_MCU=OPT_MCU_APOLLO5 AM_CFG_USB_EP5_IN_DBUF_ENABLE AM_CFG_USB_DMA_MODE_1 AM_PACKAGE_BGA CFG_TUSB_DEBUG=0 BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_HIGH_SPEED AM_CDC_USE_APP_BUF keil6
  c include: ../../../../../../third_party/tinyusb/source/src/class/msc;../../../../../../third_party/tinyusb/source/src;../../../../../../third_party/tinyusb/source/src/common;../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo330P/hal;../../../../bsp;../../../../../../third_party/tinyusb/source/src/osal;../src;../../../../../../mcu/apollo330P;../../../../../../devices;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/tinyusb/source/src/class/cdc;../../../../../../utils
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo330P/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c apollo5_board.c msc_disk.c tinyusb_cdc_msc.c usb_descriptors.c
  group tinyusb_src
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
  group tinyusb_common
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
  group tinyusb_apollo5
    ../../../../../../third_party/tinyusb/ambiq_port/apollo5/: dcd_apollo5.c
  group tinyusb_device
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
  group tinyusb_msc
    ../../../../../../third_party/tinyusb/source/src/class/msc/: msc_device.c
  group tinyusb_cdc
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.c
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo330P/hal/mcu/keil6/bin/: libam_hal.lib
software components: Device:Startup 1.1.0
