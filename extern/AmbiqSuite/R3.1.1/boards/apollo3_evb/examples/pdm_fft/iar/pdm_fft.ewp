# IAR project pdm_fft.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO3; __FPU_PRESENT; AM_UTIL_FAULTISR_PRINT; UNITY_INCLUDE_CONFIG_H
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\devices; ..\..\..\..\..; ..\..\..\..\..\mcu\apollo3; ..\..\..\bsp; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\src; ..\..\..\..\..\utils
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: pdm_fft.bin
  ILINK.IlinkOutputFile: pdm_fft.out
  ILINK.IlinkIcfFile: pdm_fft.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\..\..\CMSIS\ARM\Lib\ARM\iar_cortexM4lf_math.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO3; __FPU_PRESENT; AM_UTIL_FAULTISR_PRINT; UNITY_INCLUDE_CONFIG_H
  group (top)
    ../src/: pdm_fft.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
