# IAR project nemagfx_nemagui_ambiq_logo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; USE_TSI_MALLOC; SCENARIO_C; WALL_TIME_CLOCKS; ASSET_LOCATE_IN_PSRAM; AM_PACKAGE_BGA; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; AM_FREERTOS; CALCULATE_FPS; PLATFORM=apollo4p_nemagfx; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; USE_TOUCH; AM_PART_APOLLO4P; ENABLE_TE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\bsp; ..\src\generated; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\utils; ..\src\generated\assets\images; ..\src\generated\assets\fonts; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\src\generated\NemaGUI\include; ..\..\..\..\..\..; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\src\generated\NemaGUI\include\gitems; ..\..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo4; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4p_nemagfx; ..\..\..\..\..\..\devices; ..\src; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_nemagui_ambiq_logo.bin
  ILINK.IlinkOutputFile: nemagfx_nemagui_ambiq_logo.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\third_party\NemaGUI\config\apollo4p\iar\bin\NemaGUI.a; ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4p_nemagfx\iar\bin\lib_nema_apollo4p_nemagfx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; USE_TSI_MALLOC; SCENARIO_C; WALL_TIME_CLOCKS; ASSET_LOCATE_IN_PSRAM; AM_PACKAGE_BGA; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; AM_FREERTOS; CALCULATE_FPS; PLATFORM=apollo4p_nemagfx; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; USE_TOUCH; AM_PART_APOLLO4P; ENABLE_TE
  group (top)
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../src/: am_resources.c gui_task.c nemagfx_nemagui_ambiq_logo.c psram_malloc.c rtos.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../src/generated/: custom_callbacks.c event_list.c fonts.c framebuffers.c gui_tree.c images.c main.c screen_groups.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_mspi_psram_aps12808l.c am_devices_mspi_psram_aps25616n.c am_devices_nemadc_rm67162.c am_devices_tma525.c
    ./: startup_iar.c
