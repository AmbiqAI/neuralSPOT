# IAR project watchdog.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AP330MPA-CBR AmbiqMicro AP330MPA-CBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PART_APOLLO330P; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo330P; ..\src; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\bsp; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: watchdog.bin
  ILINK.IlinkOutputFile: watchdog.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo330P\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 1
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO330P; AM_PACKAGE_BGA
  group (top)
    ../src/: am_resources.c watchdog.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../../devices/: am_devices_led.c
    ./: startup_iar.c
