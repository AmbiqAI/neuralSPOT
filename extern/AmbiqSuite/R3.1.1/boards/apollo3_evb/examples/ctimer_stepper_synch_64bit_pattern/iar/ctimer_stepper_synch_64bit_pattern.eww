<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\ctimer_stepper_synch_64bit_pattern.ewp</path>
  </project>
  <batchBuild/>
</workspace>



