# Keil uVision project dsi_rw_command.uvprojx, settings and files
target dsi_rw_command (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: dsi_rw_command
  AfterMake: fromelf --bin --output bin\dsi_rw_command.bin bin\dsi_rw_command.axf
  AfterMake: fromelf -cedrst --output bin\dsi_rw_command.txt bin\dsi_rw_command.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK NEMA_PLATFORM=apollo4b_nemagfx BAREMETAL AM_PART_APOLLO4B LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib AM_PACKAGE_BGA keil6
  c include: ../../../../../../mcu/apollo4b;../../../../../../utils;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../mcu/apollo4b/hal/mcu;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../devices;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../src;../../../../bsp;../../../../../..;../../../../../../mcu/apollo4b/hal
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group ThinkSi_apollo4b_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group src
    ../src/: am_resources.c dsi_rw_command.c
  group devices
    ../../../../../../devices/: am_devices_dc_dsi_raydium.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/keil6/bin/: lib_nema_apollo4b_nemagfx.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
